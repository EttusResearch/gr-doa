options:
  parameters:
    author: jreitmei
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: run_RootMUSIC_lin_array
    output_language: python
    title: run_RootMUSIC_lin_array
  states: {}

blocks:
- name: input_variables
  id: variable_struct
  parameters:
    comment: |-
      input_variables: 
      Contains all the user-defined variables.
    field0: ''
    field1: SampleRate
    field10: DirectoryConfigFiles
    field11: RelativePhaseOffsets
    field2: CenterFreq
    field3: RxAddr
    field5: NumArrayElements
    field6: NormSpacing
    field7: SnapshotSize
    field8: OverlapSize
    field9: NumTargets
    value1: 1e6
    value10: '"/tmp"'
    value11: '"measure_relative_phase_offsets_446MHz.cfg"'
    value2: '446031250 '
    value3: '"addr=10.94.17.47"'
    value5: '4'
    value6: '0.5'
    value7: 2**12
    value8: 2**11
    value9: '1'
  states: {}
- name: rel_phase_offsets_file_name
  id: variable
  parameters:
    value: os.path.join(input_variables.DirectoryConfigFiles, input_variables.RelativePhaseOffsets)
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '10'
    type: float
  states: {}
- name: doa_autocorrelate_0_0
  id: doa_autocorrelate
  parameters:
    avg_method: Forward
    inputs: input_variables.NumArrayElements
    overlap_size: input_variables.OverlapSize
    snapshot_size: input_variables.SnapshotSize
  states: {}
- name: doa_phase_correct_hier_0
  id: doa_phase_correct_hier
  parameters:
    config_filename: rel_phase_offsets_file_name
    num_ports: input_variables.NumArrayElements
  states: {}
- name: doa_rootMUSIC_linear_array_0_0
  id: doa_rootMUSIC_linear_array
  parameters:
    norm_spacing: input_variables.NormSpacing
    num_ant_ele: '4'
    num_targets: input_variables.NumTargets
  states: {}
- name: doa_serial_connection_0_0
  id: doa_serial_connection
  parameters:
    baudrate: '115200'
    debug: 'False'
    dimensions: '1'
    high_hysteresis: '25.0'
    low_hysteresis: '5'
    mirror: 'True'
    port: /dev/ttyACM0
  states: {}
- name: doa_x440_usrp_source_0
  id: doa_x440_usrp_source
  parameters:
    addresses: input_variables.RxAddr
    center_freq: input_variables.CenterFreq
    device_args: master_clock_rate=250e6
    samp_rate: input_variables.SampleRate
    sources: input_variables.NumArrayElements
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_compass_0
  id: qtgui_compass
  parameters:
    fullNeedle: '1'
    min_size: '250'
    name: Direction
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '180'
    min: '0'
    type: float
  states: {}

connections:
- [blocks_keep_one_in_n_0, '0', doa_serial_connection_0_0, '0']
- [doa_autocorrelate_0_0, '0', doa_rootMUSIC_linear_array_0_0, '0']
- [doa_phase_correct_hier_0, '0', doa_autocorrelate_0_0, '0']
- [doa_phase_correct_hier_0, '1', doa_autocorrelate_0_0, '1']
- [doa_phase_correct_hier_0, '2', doa_autocorrelate_0_0, '2']
- [doa_phase_correct_hier_0, '3', doa_autocorrelate_0_0, '3']
- [doa_rootMUSIC_linear_array_0_0, '0', blocks_keep_one_in_n_0, '0']
- [doa_rootMUSIC_linear_array_0_0, '0', qtgui_compass_0, '0']
- [doa_rootMUSIC_linear_array_0_0, '0', qtgui_number_sink_1, '0']
- [doa_x440_usrp_source_0, '0', doa_phase_correct_hier_0, '0']
- [doa_x440_usrp_source_0, '1', doa_phase_correct_hier_0, '1']
- [doa_x440_usrp_source_0, '2', doa_phase_correct_hier_0, '2']
- [doa_x440_usrp_source_0, '3', doa_phase_correct_hier_0, '3']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-992-ga7b5ef78
