options:
  parameters:
    author: jreitmei
    generate_options: no_gui
    generator_class_name: PythonNoGuiGenerator
    generator_module: gnuradio.grc.workflows.python_nogui
    id: run_DoA_transmitter
    output_language: python
    title: run_DoA_transmitter
  states: {}

blocks:
- name: input_variables
  id: variable_struct
  parameters:
    comment: |-
      input_variables: 
      Contains all the user-defined variables.
    field0: ToneFreq
    field1: SampleRate
    field2: CenterFreq
    field3: TxAddr
    field4: Gain
    value0: 10e3
    value1: 1e6
    value2: '446031250 '
    value3: '"addr=192.168.10.2"'
    value4: '30'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: input_variables.ToneFreq
    offset: '0'
    phase: '0'
    samp_rate: input_variables.SampleRate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: input_variables.SampleRate
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: input_variables.CenterFreq
    clock_rate: '0.0'
    clock_source0: internal
    dev_addr: input_variables.TxAddr
    dev_args: '""'
    gain0: input_variables.Gain
    len_tag_name: ''
    samp_rate: input_variables.SampleRate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-992-ga7b5ef78
