options:
  parameters:
    author: jreitmei
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: run_MUSIC_lin_array
    output_language: python
    title: run_MUSIC_lin_array
  states: {}

blocks:
- name: ant_locs
  id: variable
  parameters:
    value: numpy.dot(input_variables.NormSpacing, numpy.arange(input_variables.NumArrayElements/2, -input_variables.NumArrayElements/2, -1) if (input_variables.NumArrayElements%2==1) else numpy.arange(input_variables.NumArrayElements/2-0.5, -input_variables.NumArrayElements/2-0.5, -1))
  states: {}
- name: input_variables
  id: variable_struct
  parameters:
    comment: |-
      input_variables: 
      Contains all the user-defined variables.
    field0: ''
    field1: SampleRate
    field10: PSpectrumLength
    field11: DirectoryConfigFiles
    field12: RelativePhaseOffsets
    field2: CenterFreq
    field3: RxAddr
    field5: NumArrayElements
    field6: NormSpacing
    field7: SnapshotSize
    field8: OverlapSize
    field9: NumTargets
    value1: 1e6
    value10: 2**10
    value11: '"/tmp"'
    value12: '"measure_relative_phase_offsets_2495MHz.cfg"'
    value2: 2.495e9
    value3: '"addr=10.94.17.50"'
    value5: '4'
    value6: '0.5'
    value7: 2**15
    value8: 2**14
    value9: '1'
  states: {}
- name: rel_phase_offsets_file_name
  id: variable
  parameters:
    value: os.path.join(input_variables.DirectoryConfigFiles, input_variables.RelativePhaseOffsets)
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '5'
    max_iter: '1000'
    scale: 1/5
    type: float
  states: {state: disabled}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '5'
    max_iter: '1000'
    scale: 1/5
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: input_variables.NumTargets
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: input_variables.NumTargets
    type: float
  states: {}
- name: doa_MUSIC_lin_array_0
  id: doa_MUSIC_lin_array
  parameters:
    inputs: input_variables.NumArrayElements
    norm_spacing: input_variables.NormSpacing
    num_targets: input_variables.NumTargets
    pspectrum_len: input_variables.PSpectrumLength
  states: {}
- name: doa_autocorrelate_0
  id: doa_autocorrelate
  parameters:
    avg_method: Forward-Backward
    inputs: input_variables.NumArrayElements
    overlap_size: input_variables.OverlapSize
    snapshot_size: input_variables.SnapshotSize
  states: {}
- name: doa_find_local_max_0
  id: doa_find_local_max
  parameters:
    num_max_vals: input_variables.NumTargets
    vector_len: input_variables.PSpectrumLength
    x_max: '180.0'
    x_min: '0.0'
  states: {}
- name: doa_phase_correct_hier_0
  id: doa_phase_correct_hier
  parameters:
    config_filename: rel_phase_offsets_file_name
    num_ports: input_variables.NumArrayElements
  states: {}
- name: doa_serial_connection_0
  id: doa_serial_connection
  parameters:
    baudrate: '115200'
    debug: 'False'
    dimensions: '1'
    high_hysteresis: '15.0'
    low_hysteresis: '3.0'
    port: /dev/ttyACM0
  states: {state: disabled}
- name: doa_serial_connection_0_0
  id: doa_serial_connection
  parameters:
    baudrate: '115200'
    debug: 'False'
    dimensions: '1'
    high_hysteresis: '25.0'
    low_hysteresis: '5'
    port: /dev/ttyACM0
  states: {}
- name: doa_x440_usrp_source_0
  id: doa_x440_usrp_source
  parameters:
    addresses: input_variables.RxAddr
    center_freq: input_variables.CenterFreq
    device_args: master_clock_rate=250e6
    samp_rate: input_variables.SampleRate
    sources: input_variables.NumArrayElements
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nfrom datetime import datetime\nimport os\n\nclass blk(gr.sync_block):\n    \"\"\"Triggered Float Recorder with Sample Skipping\"\"\"\n\n    def __init__(self, skip_interval=20):\n        gr.sync_block.__init__(\n            self,\n            name='Triggered Float Recorder with Skipping',\n            in_sig=[np.float32],\n            out_sig=[]\n        )\n\n        self.angle = 0\n        self.folder = \"testdata\"\n        os.makedirs(self.folder, exist_ok=True)\n\n        self.recording = False\n        self.skip_interval = skip_interval\n        self.samples_to_record = 10\n        self.skip_counter = 0\n        self.recorded_samples = []\n\n        # Message-Port für Trigger\n        self.message_port_register_in(gr.pmt.intern(\"in\"))\n        self.set_msg_handler(gr.pmt.intern(\"in\"), self.handle_trigger)\n\n    def handle_trigger(self, msg):\n        if not self.recording and self.angle <= 180:\n            print(f\"[Trigger] Aufnahme gestartet bei Winkel {self.angle}°\")\n            self.recording = True\n            self.recorded_samples = []\n            self.skip_counter = 0\n\n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n\n        for sample in in0:\n            if self.recording:\n                if self.skip_counter == 0:\n                    self.recorded_samples.append(sample)\n                    self.skip_counter = self.skip_interval\n                else:\n                    self.skip_counter -= 1\n\n                if len(self.recorded_samples) >= self.samples_to_record:\n                    # Speichern\n                    timestamp = datetime.now().strftime(\"%Y%m%d_%H%M%S\")\n                    filename = f\"aufnahme_{self.angle}deg_{timestamp}.dat\"\n                    filepath = os.path.join(self.folder, filename)\n\n                    with open(filepath, \"w\") as f:\n                        for s in self.recorded_samples:\n                            f.write(f\"{s}\\n\")\n\n                    print(f\"[Recorder] Datei gespeichert: {filepath}\")\n\n                    # Aufnahme zurücksetzen\n                    self.recording = False\n                    self.angle += 10\n\n                    if self.angle > 180:\n                        print(\"[Recorder] Maximale Winkelgrenze erreicht. Aufnahme beendet.\")\n                    break  # Aufnahme abgeschlossen\n\n        return len(in0)\n\n"
    skip_interval: '10'
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '180'
    min: '0'
    nconnections: input_variables.NumTargets
    type: float
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    showports: 'True'
    update_time: '0.05'
    vlen: input_variables.PSpectrumLength
    width1: '2'
    x_axis_label: '"angle (in degrees)"'
    x_start: '0'
    x_step: 180.0/input_variables.PSpectrumLength
    y_axis_label: '"Pseudo-Spectrum (dB)"'
    ymax: '0'
    ymin: '-15'
  states: {}
- name: variable_qtgui_msg_push_button_0
  id: variable_qtgui_msg_push_button
  parameters:
    label: Trigger_values
    msgName: pressed
    type: int
    value: '1'
  states: {state: disabled}

connections:
- [blocks_moving_average_xx_0, '0', doa_serial_connection_0, '0']
- [blocks_moving_average_xx_0_0, '0', doa_serial_connection_0_0, '0']
- [blocks_vector_to_streams_0, '0', epy_block_0, '0']
- [blocks_vector_to_streams_0, '0', qtgui_number_sink_1, '0']
- [doa_MUSIC_lin_array_0, '0', doa_find_local_max_0, '0']
- [doa_MUSIC_lin_array_0, '0', qtgui_vector_sink_f_0, '0']
- [doa_autocorrelate_0, '0', doa_MUSIC_lin_array_0, '0']
- [doa_find_local_max_0, '0', blocks_null_sink_0, '0']
- [doa_find_local_max_0, '1', blocks_moving_average_xx_0, '0']
- [doa_find_local_max_0, '1', blocks_moving_average_xx_0_0, '0']
- [doa_find_local_max_0, '1', blocks_vector_to_streams_0, '0']
- [doa_find_local_max_0, '1', doa_serial_connection_0_0, '0']
- [doa_phase_correct_hier_0, '0', doa_autocorrelate_0, '0']
- [doa_phase_correct_hier_0, '1', doa_autocorrelate_0, '1']
- [doa_phase_correct_hier_0, '2', doa_autocorrelate_0, '2']
- [doa_phase_correct_hier_0, '3', doa_autocorrelate_0, '3']
- [doa_x440_usrp_source_0, '0', doa_phase_correct_hier_0, '0']
- [doa_x440_usrp_source_0, '1', doa_phase_correct_hier_0, '1']
- [doa_x440_usrp_source_0, '2', doa_phase_correct_hier_0, '2']
- [doa_x440_usrp_source_0, '3', doa_phase_correct_hier_0, '3']
- [variable_qtgui_msg_push_button_0, pressed, epy_block_0, in]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-991-g721e477c
