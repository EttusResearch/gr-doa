options:
  parameters:
    author: jreitmei
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: view_op_with_corrected_phase_offsets
    output_language: python
    title: Overview after phase correction
  states: {}

blocks:
- name: input_variables
  id: variable_struct
  parameters:
    comment: |-
      input_variables: 
      Contains all the user-defined variables.
    field0: SampleRate
    field2: CenterFreq
    field4: NumArrayElements
    field5: RxAddr
    field6: DirectoryConfigFiles
    field7: RelativePhaseOffsets
    value0: 1e6
    value2: 2.495e9
    value4: '8'
    value5: '"addr=10.94.17.62"'
    value6: '"/tmp"'
    value7: '"measure_relative_phase_offsets_2495MHz.cfg"'
  states: {}
- name: rel_phase_offsets_file_name
  id: variable
  parameters:
    value: os.path.join(input_variables.DirectoryConfigFiles, input_variables.RelativePhaseOffsets)
  states: {}
- name: doa_phase_correct_hier_0
  id: doa_phase_correct_hier
  parameters:
    config_filename: rel_phase_offsets_file_name
    num_ports: input_variables.NumArrayElements
  states: {}
- name: doa_x440_usrp_source_0
  id: doa_x440_usrp_source
  parameters:
    addresses: input_variables.RxAddr
    center_freq: input_variables.CenterFreq
    device_args: master_clock_rate=250e6
    samp_rate: input_variables.SampleRate
    sources: input_variables.NumArrayElements
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    color1: black
    color3: black
    color5: black
    color7: black
    label1: Signal 1 - Real
    label3: Signal 3 - Real
    label5: Signal 5 - Real
    label7: Signal 7 - Real
    name: '"view signals with phase correction"'
    nconnections: '4'
    size: '256'
    srate: input_variables.SampleRate
    style2: '0'
    style4: '0'
    style6: '0'
    style8: '0'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    color1: black
    color3: black
    color5: black
    color7: black
    label1: Signal 1 - Real
    label3: Signal 3 - Real
    label5: Signal 5 - Real
    label7: Signal 7 - Real
    name: '"view signals with phase correction"'
    nconnections: '4'
    size: '256'
    srate: input_variables.SampleRate
    style2: '0'
    style4: '0'
    style6: '0'
    style8: '0'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: complex
  states: {}

connections:
- [doa_phase_correct_hier_0, '0', qtgui_time_sink_x_0, '0']
- [doa_phase_correct_hier_0, '1', qtgui_time_sink_x_0, '1']
- [doa_phase_correct_hier_0, '2', qtgui_time_sink_x_0, '2']
- [doa_phase_correct_hier_0, '3', qtgui_time_sink_x_0, '3']
- [doa_phase_correct_hier_0, '4', qtgui_time_sink_x_0_0, '0']
- [doa_phase_correct_hier_0, '5', qtgui_time_sink_x_0_0, '1']
- [doa_phase_correct_hier_0, '6', qtgui_time_sink_x_0_0, '2']
- [doa_phase_correct_hier_0, '7', qtgui_time_sink_x_0_0, '3']
- [doa_x440_usrp_source_0, '0', doa_phase_correct_hier_0, '0']
- [doa_x440_usrp_source_0, '1', doa_phase_correct_hier_0, '1']
- [doa_x440_usrp_source_0, '2', doa_phase_correct_hier_0, '2']
- [doa_x440_usrp_source_0, '3', doa_phase_correct_hier_0, '3']
- [doa_x440_usrp_source_0, '4', doa_phase_correct_hier_0, '4']
- [doa_x440_usrp_source_0, '5', doa_phase_correct_hier_0, '5']
- [doa_x440_usrp_source_0, '6', doa_phase_correct_hier_0, '6']
- [doa_x440_usrp_source_0, '7', doa_phase_correct_hier_0, '7']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-992-ga7b5ef78
