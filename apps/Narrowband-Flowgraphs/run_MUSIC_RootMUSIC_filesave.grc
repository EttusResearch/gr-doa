options:
  parameters:
    author: jreitmei
    comment: |-
      This flowgraph measures every single configuration and saves them into a file. 
      Configurations used:
      e.g.
      MUSIC Uncalibrated
      RootMUSIC Uncalibrated
      MUSIC Calibrated
      RootMUSIC Calibrated
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: run_MUSIC_RootMUSIC_filesave
    output_language: python
    title: MUSIC RootMUSIC filesave
  states: {}

blocks:
- name: antenna_calibration_file_name
  id: variable
  parameters:
    value: os.path.join(input_variables.DirectoryConfigFiles, input_variables.AntennaCalibration)
  states: {}
- name: input_variables
  id: variable_struct
  parameters:
    comment: |-
      input_variables: 
      Contains all the user-defined variables.
    field0: ''
    field1: SampleRate
    field10: PSpectrumLength
    field11: DirectoryConfigFiles
    field12: RelativePhaseOffsets
    field13: AntennaCalibration
    field2: CenterFreq
    field3: RxAddr
    field5: NumArrayElements
    field6: NormSpacing
    field7: SnapshotSize
    field8: OverlapSize
    field9: NumTargets
    value1: 1e6
    value10: 2**10
    value11: '"/tmp"'
    value12: '"measure_relative_phase_offsets_2495MHz.cfg"'
    value13: '"calibration_lin_array_2495MHz.cfg"'
    value2: 2.495e9
    value3: '"addr=10.94.17.47"'
    value5: '4'
    value6: '0.5'
    value7: 2**11
    value8: 2**10
    value9: '1'
  states: {}
- name: rel_phase_offsets_file_name
  id: variable
  parameters:
    value: os.path.join(input_variables.DirectoryConfigFiles, input_variables.RelativePhaseOffsets)
  states: {}
- name: blocks_complex_to_arg_0_0_0_0_1
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0_0_0_1_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0_0_1
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0_0_1_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0_1
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0_1_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {}
- name: blocks_divide_xx_0_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {}
- name: blocks_divide_xx_0_0_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {}
- name: blocks_divide_xx_0_0_0_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {}
- name: blocks_divide_xx_0_0_1
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {}
- name: blocks_divide_xx_0_1
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    num_inputs: '2'
    type: float
    vlen: input_variables.NumTargets
  states: {}
- name: doa_MUSIC_lin_array_0
  id: doa_MUSIC_lin_array
  parameters:
    inputs: input_variables.NumArrayElements
    norm_spacing: input_variables.NormSpacing
    num_targets: input_variables.NumTargets
    pspectrum_len: input_variables.PSpectrumLength
  states: {}
- name: doa_MUSIC_lin_array_0_0
  id: doa_MUSIC_lin_array
  parameters:
    inputs: input_variables.NumArrayElements
    norm_spacing: input_variables.NormSpacing
    num_targets: input_variables.NumTargets
    pspectrum_len: input_variables.PSpectrumLength
  states: {}
- name: doa_antenna_correction_0
  id: doa_antenna_correction
  parameters:
    config_filename: antenna_calibration_file_name
    num_ant_ele: input_variables.NumArrayElements
  states: {}
- name: doa_autocorrelate_0
  id: doa_autocorrelate
  parameters:
    avg_method: Forward-Backward
    inputs: input_variables.NumArrayElements
    overlap_size: input_variables.OverlapSize
    snapshot_size: input_variables.SnapshotSize
  states: {}
- name: doa_autocorrelate_0_0
  id: doa_autocorrelate
  parameters:
    avg_method: Forward-Backward
    inputs: input_variables.NumArrayElements
    overlap_size: input_variables.OverlapSize
    snapshot_size: input_variables.SnapshotSize
  states: {}
- name: doa_find_local_max_0
  id: doa_find_local_max
  parameters:
    num_max_vals: input_variables.NumTargets
    vector_len: input_variables.PSpectrumLength
    x_max: '180.0'
    x_min: '0.0'
  states: {}
- name: doa_find_local_max_0_0
  id: doa_find_local_max
  parameters:
    num_max_vals: input_variables.NumTargets
    vector_len: input_variables.PSpectrumLength
    x_max: '180.0'
    x_min: '0.0'
  states: {}
- name: doa_phase_correct_hier_0_0
  id: doa_phase_correct_hier
  parameters:
    config_filename: rel_phase_offsets_file_name
    num_ports: input_variables.NumArrayElements
  states: {}
- name: doa_rootMUSIC_linear_array_0
  id: doa_rootMUSIC_linear_array
  parameters:
    norm_spacing: input_variables.NormSpacing
    num_ant_ele: '4'
    num_targets: input_variables.NumTargets
  states: {}
- name: doa_rootMUSIC_linear_array_0_0
  id: doa_rootMUSIC_linear_array
  parameters:
    norm_spacing: input_variables.NormSpacing
    num_ant_ele: '4'
    num_targets: input_variables.NumTargets
  states: {}
- name: doa_x440_usrp_source_0
  id: doa_x440_usrp_source
  parameters:
    addresses: input_variables.RxAddr
    center_freq: input_variables.CenterFreq
    device_args: master_clock_rate=250e6
    samp_rate: input_variables.SampleRate
    sources: input_variables.NumArrayElements
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nfrom datetime import datetime\nimport os\n\nclass blk(gr.sync_block):\n    \"\"\"Triggered Float Recorder with Sample Skipping\"\"\"\n\n    def __init__(self, skip_interval=20, samples_to_record=10):\n        gr.sync_block.__init__(\n            self,\n            name='RootMUSIC_calibrated',\n            in_sig=[np.float32],\n            out_sig=[]\n        )\n\n        self.angle = 0\n        self.folder = \"testdata/calibrated/RootMUSIC\"\n        os.makedirs(self.folder, exist_ok=True)\n\n        self.recording = False\n        self.skip_interval = skip_interval\n        self.samples_to_record = samples_to_record\n        self.recorded_samples = []\n        self.sample_counter = 0\n\n        # Message-Port für Trigger\n        self.message_port_register_in(gr.pmt.intern(\"in\"))\n        self.set_msg_handler(gr.pmt.intern(\"in\"), self.handle_trigger)\n\n    def handle_trigger(self, msg):\n        if not self.recording and self.angle <= 180:\n            print(f\"[Trigger] Recording started at angle {self.angle}°\")\n            self.recording = True\n            self.recorded_samples = []\n            self.sample_counter = 0\n\n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n\n        for sample in in0:\n            if self.recording:\n                # Only record every skip_interval-th sample using modulo\n                if self.sample_counter % self.skip_interval == 0:\n                    self.recorded_samples.append(sample)\n\n                self.sample_counter += 1\n\n                if len(self.recorded_samples) >= self.samples_to_record:\n                    # Save\n                    timestamp = datetime.now().strftime(\"%Y%m%d_%H%M%S\")\n                    filename = f\"record_{self.angle}deg_{timestamp}.dat\"\n                    filepath = os.path.join(self.folder, filename)\n\n                    with open(filepath, \"w\") as f:\n                        for s in self.recorded_samples:\n                            f.write(f\"{s}\\n\")\n\n                    print(f\"[Recorder] File saved: {filepath}\")\n\n                    # reset recording\n                    self.recording = False\n                    self.angle += 10\n\n                    if self.angle > 180:\n                        print(\"[Recorder] Maximum angle limit reached. Recording stopped.\")\n                    break  # recording finished\n\n        return len(in0)\n\n"
    samples_to_record: '10'
    skip_interval: '50'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nfrom datetime import datetime\nimport os\n\nclass blk(gr.sync_block):\n    \"\"\"Triggered Float Recorder with Sample Skipping\"\"\"\n\n    def __init__(self, skip_interval=20, samples_to_record=10):\n        gr.sync_block.__init__(\n            self,\n            name='RootMUSIC_uncalibrated',\n            in_sig=[np.float32],\n            out_sig=[]\n        )\n\n        self.angle = 0\n        self.folder = \"testdata/uncalibrated/RootMUSIC\"\n        os.makedirs(self.folder, exist_ok=True)\n\n        self.recording = False\n        self.skip_interval = skip_interval\n        self.samples_to_record = samples_to_record\n        self.recorded_samples = []\n        self.sample_counter = 0\n\n        # Message-Port für Trigger\n        self.message_port_register_in(gr.pmt.intern(\"in\"))\n        self.set_msg_handler(gr.pmt.intern(\"in\"), self.handle_trigger)\n\n    def handle_trigger(self, msg):\n        if not self.recording and self.angle <= 180:\n            print(f\"[Trigger] Recording started at angle {self.angle}°\")\n            self.recording = True\n            self.recorded_samples = []\n            self.sample_counter = 0\n\n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n\n        for sample in in0:\n            if self.recording:\n                # Only record every skip_interval-th sample using modulo\n                if self.sample_counter % self.skip_interval == 0:\n                    self.recorded_samples.append(sample)\n\n                self.sample_counter += 1\n\n                if len(self.recorded_samples) >= self.samples_to_record:\n                    # Save\n                    timestamp = datetime.now().strftime(\"%Y%m%d_%H%M%S\")\n                    filename = f\"record_{self.angle}deg_{timestamp}.dat\"\n                    filepath = os.path.join(self.folder, filename)\n\n                    with open(filepath, \"w\") as f:\n                        for s in self.recorded_samples:\n                            f.write(f\"{s}\\n\")\n\n                    print(f\"[Recorder] File saved: {filepath}\")\n\n                    # reset recording\n                    self.recording = False\n                    self.angle += 10\n\n                    if self.angle > 180:\n                        print(\"[Recorder] Maximum angle limit reached. Recording stopped.\")\n                    break  # recording finished\n\n        return len(in0)\n\n"
    samples_to_record: '10'
    skip_interval: '50'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nfrom datetime import datetime\nimport os\n\nclass blk(gr.sync_block):\n    \"\"\"Triggered Float Recorder with Sample Skipping\"\"\"\n\n    def __init__(self, skip_interval=20, samples_to_record=10):\n        gr.sync_block.__init__(\n            self,\n            name='MUSIC_uncalibrated',\n            in_sig=[np.float32],\n            out_sig=[]\n        )\n\n        self.angle = 0\n        self.folder = \"testdata/uncalibrated/MUSIC\"\n        os.makedirs(self.folder, exist_ok=True)\n\n        self.recording = False\n        self.skip_interval = skip_interval\n        self.samples_to_record = samples_to_record\n        self.recorded_samples = []\n        self.sample_counter = 0\n\n        # Message-Port für Trigger\n        self.message_port_register_in(gr.pmt.intern(\"in\"))\n        self.set_msg_handler(gr.pmt.intern(\"in\"), self.handle_trigger)\n\n    def handle_trigger(self, msg):\n        if not self.recording and self.angle <= 180:\n            print(f\"[Trigger] Recording started at angle {self.angle}°\")\n            self.recording = True\n            self.recorded_samples = []\n            self.sample_counter = 0\n\n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n\n        for sample in in0:\n            if self.recording:\n                # Only record every skip_interval-th sample using modulo\n                if self.sample_counter % self.skip_interval == 0:\n                    self.recorded_samples.append(sample)\n\n                self.sample_counter += 1\n\n                if len(self.recorded_samples) >= self.samples_to_record:\n                    # Save\n                    timestamp = datetime.now().strftime(\"%Y%m%d_%H%M%S\")\n                    filename = f\"record_{self.angle}deg_{timestamp}.dat\"\n                    filepath = os.path.join(self.folder, filename)\n\n                    with open(filepath, \"w\") as f:\n                        for s in self.recorded_samples:\n                            f.write(f\"{s}\\n\")\n\n                    print(f\"[Recorder] File saved: {filepath}\")\n\n                    # reset recording\n                    self.recording = False\n                    self.angle += 10\n\n                    if self.angle > 180:\n                        print(\"[Recorder] Maximum angle limit reached. Recording stopped.\")\n                    break  # recording finished\n\n        return len(in0)\n\n"
    samples_to_record: '10'
    skip_interval: '50'
  states: {}
- name: epy_block_3
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nfrom datetime import datetime\nimport os\n\nclass blk(gr.sync_block):\n    \"\"\"Triggered Float Recorder with Sample Skipping\"\"\"\n\n    def __init__(self, skip_interval=20, samples_to_record=10):\n        gr.sync_block.__init__(\n            self,\n            name='MUSIC_calibrated',\n            in_sig=[np.float32],\n            out_sig=[]\n        )\n\n        self.angle = 0\n        self.folder = \"testdata/calibrated/MUSIC\"\n        os.makedirs(self.folder, exist_ok=True)\n\n        self.recording = False\n        self.skip_interval = skip_interval\n        self.samples_to_record = samples_to_record\n        self.recorded_samples = []\n        self.sample_counter = 0\n\n        # Message-Port für Trigger\n        self.message_port_register_in(gr.pmt.intern(\"in\"))\n        self.set_msg_handler(gr.pmt.intern(\"in\"), self.handle_trigger)\n\n    def handle_trigger(self, msg):\n        if not self.recording and self.angle <= 180:\n            print(f\"[Trigger] Recording started at angle {self.angle}°\")\n            self.recording = True\n            self.recorded_samples = []\n            self.sample_counter = 0\n\n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n\n        for sample in in0:\n            if self.recording:\n                # Only record every skip_interval-th sample using modulo\n                if self.sample_counter % self.skip_interval == 0:\n                    self.recorded_samples.append(sample)\n\n                self.sample_counter += 1\n\n                if len(self.recorded_samples) >= self.samples_to_record:\n                    # Save\n                    timestamp = datetime.now().strftime(\"%Y%m%d_%H%M%S\")\n                    filename = f\"record_{self.angle}deg_{timestamp}.dat\"\n                    filepath = os.path.join(self.folder, filename)\n\n                    with open(filepath, \"w\") as f:\n                        for s in self.recorded_samples:\n                            f.write(f\"{s}\\n\")\n\n                    print(f\"[Recorder] File saved: {filepath}\")\n\n                    # reset recording\n                    self.recording = False\n                    self.angle += 10\n\n                    if self.angle > 180:\n                        print(\"[Recorder] Maximum angle limit reached. Recording stopped.\")\n                    break  # recording finished\n\n        return len(in0)\n\n"
    samples_to_record: '10'
    skip_interval: '50'
  states: {}
- name: epy_block_4
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import os
      from datetime import datetime


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Triggered 3-Channel Float Recorder with Angle Stepping"""

          def __init__(self, skip_interval=20, samples_to_record=10):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='3-Channel Phase Offset Recorder',   # will show up in GRC
                  in_sig=[np.float32, np.float32, np.float32],  # 3 float inputs
                  out_sig=[]  # no outputs, this is a sink block
              )
              
              self.angle = 0
              self.folder = "testdata/phase_offsets"
              os.makedirs(self.folder, exist_ok=True)
              
              self.recording = False
              self.skip_interval = skip_interval
              self.samples_to_record = samples_to_record
              self.recorded_samples = [[], [], []]  # separate lists for each channel
              self.sample_counter = 0
              
              # Message-Port for Trigger
              self.message_port_register_in(gr.pmt.intern("in"))
              self.set_msg_handler(gr.pmt.intern("in"), self.handle_trigger)

          def handle_trigger(self, msg):
              if not self.recording and self.angle <= 180:
                  print(f"[Trigger] Recording started at angle {self.angle}°")
                  self.recording = True
                  self.recorded_samples = [[], [], []]  # reset all channels
                  self.sample_counter = 0

          def work(self, input_items, output_items):
              """Record samples from 3 channels with trigger and angle stepping"""
              if not self.recording:
                  return len(input_items[0])
              
              # Get the minimum length across all input channels for this work call
              min_len = min(len(input_items[0]), len(input_items[1]), len(input_items[2]))
              
              for i in range(min_len):
                  if self.recording:
                      # Only record every skip_interval-th sample using modulo
                      if self.sample_counter % self.skip_interval == 0:
                          # Record from all channels simultaneously
                          self.recorded_samples[0].append(float(input_items[0][i]))
                          self.recorded_samples[1].append(float(input_items[1][i]))
                          self.recorded_samples[2].append(float(input_items[2][i]))
                      
                      self.sample_counter += 1
                      
                      # Check if we have enough samples
                      if len(self.recorded_samples[0]) >= self.samples_to_record:
                          self._save_file()
                          self.recording = False
                          self.angle += 10
                          
                          if self.angle > 180:
                              print("[Recorder] Maximum angle limit reached. Recording stopped.")
                          break  # recording finished for this trigger
              
              return len(input_items[0])
          
          def _save_file(self):
              """Save recorded samples to file"""
              # Safety check: ensure all channels have data
              if not all(len(channel_data) > 0 for channel_data in self.recorded_samples):
                  print("[Recorder] Error: Not all channels have data. Skipping save.")
                  return
              
              # Use the minimum length to avoid index errors
              min_samples = min(len(channel_data) for channel_data in self.recorded_samples)
              if min_samples == 0:
                  print("[Recorder] Error: No samples recorded. Skipping save.")
                  return
              
              timestamp = datetime.now().strftime("%Y%m%d_%H%M%S")
              filename = f"phase_offset_{self.angle}deg_{timestamp}.dat"
              filepath = os.path.join(self.folder, filename)
              
              with open(filepath, "w") as f:
                  f.write(f"# 3-Channel Phase Offset Recording\n")
                  f.write(f"# Angle: {self.angle}°\n")
                  f.write(f"# Timestamp: {timestamp}\n")
                  f.write(f"# Samples per channel: {min_samples}\n")
                  f.write(f"# Format: Channel_0, Channel_1, Channel_2\n")
                  f.write("#\n")
                  
                  # Write values row by row using min_samples to avoid index errors
                  for i in range(min_samples):
                      values = [
                          self.recorded_samples[0][i],
                          self.recorded_samples[1][i], 
                          self.recorded_samples[2][i]
                      ]
                      f.write(f"{values[0]:.6f}, {values[1]:.6f}, {values[2]:.6f}\n")
              
              print(f"[Recorder] File saved: {filepath} with {min_samples} samples")
    samples_to_record: '5'
    skip_interval: '1'
  states: {}
- name: epy_block_5
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import os
      from datetime import datetime


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Triggered 3-Channel Float Recorder with Angle Stepping"""

          def __init__(self, skip_interval=20, samples_to_record=10):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='3-Channel Phase Offset Recorder',   # will show up in GRC
                  in_sig=[np.float32, np.float32, np.float32],  # 3 float inputs
                  out_sig=[]  # no outputs, this is a sink block
              )
              
              self.angle = 0
              self.folder = "testdata/phase_offsets/calibrated"
              os.makedirs(self.folder, exist_ok=True)
              
              self.recording = False
              self.skip_interval = skip_interval
              self.samples_to_record = samples_to_record
              self.recorded_samples = [[], [], []]  # separate lists for each channel
              self.sample_counter = 0
              
              # Message-Port for Trigger
              self.message_port_register_in(gr.pmt.intern("in"))
              self.set_msg_handler(gr.pmt.intern("in"), self.handle_trigger)

          def handle_trigger(self, msg):
              if not self.recording and self.angle <= 180:
                  print(f"[Trigger] Recording started at angle {self.angle}°")
                  self.recording = True
                  self.recorded_samples = [[], [], []]  # reset all channels
                  self.sample_counter = 0

          def work(self, input_items, output_items):
              """Record samples from 3 channels with trigger and angle stepping"""
              if not self.recording:
                  return len(input_items[0])
              
              # Get the minimum length across all input channels for this work call
              min_len = min(len(input_items[0]), len(input_items[1]), len(input_items[2]))
              
              for i in range(min_len):
                  if self.recording:
                      # Only record every skip_interval-th sample using modulo
                      if self.sample_counter % self.skip_interval == 0:
                          # Record from all channels simultaneously
                          self.recorded_samples[0].append(float(input_items[0][i]))
                          self.recorded_samples[1].append(float(input_items[1][i]))
                          self.recorded_samples[2].append(float(input_items[2][i]))
                      
                      self.sample_counter += 1
                      
                      # Check if we have enough samples
                      if len(self.recorded_samples[0]) >= self.samples_to_record:
                          self._save_file()
                          self.recording = False
                          self.angle += 10
                          
                          if self.angle > 180:
                              print("[Recorder] Maximum angle limit reached. Recording stopped.")
                          break  # recording finished for this trigger
              
              return len(input_items[0])
          
          def _save_file(self):
              """Save recorded samples to file"""
              # Safety check: ensure all channels have data
              if not all(len(channel_data) > 0 for channel_data in self.recorded_samples):
                  print("[Recorder] Error: Not all channels have data. Skipping save.")
                  return
              
              # Use the minimum length to avoid index errors
              min_samples = min(len(channel_data) for channel_data in self.recorded_samples)
              if min_samples == 0:
                  print("[Recorder] Error: No samples recorded. Skipping save.")
                  return
              
              timestamp = datetime.now().strftime("%Y%m%d_%H%M%S")
              filename = f"phase_offset_{self.angle}deg_{timestamp}.dat"
              filepath = os.path.join(self.folder, filename)
              
              with open(filepath, "w") as f:
                  f.write(f"# 3-Channel Phase Offset Recording\n")
                  f.write(f"# Angle: {self.angle}°\n")
                  f.write(f"# Timestamp: {timestamp}\n")
                  f.write(f"# Samples per channel: {min_samples}\n")
                  f.write(f"# Format: Channel_0, Channel_1, Channel_2\n")
                  f.write("#\n")
                  
                  # Write values row by row using min_samples to avoid index errors
                  for i in range(min_samples):
                      values = [
                          self.recorded_samples[0][i],
                          self.recorded_samples[1][i], 
                          self.recorded_samples[2][i]
                      ]
                      f.write(f"{values[0]:.6f}, {values[1]:.6f}, {values[2]:.6f}\n")
              
              print(f"[Recorder] File saved: {filepath} with {min_samples} samples")
    samples_to_record: '5'
    skip_interval: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_number_sink_1_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: uncalibrated
    label2: calibrated
    max: '180'
    min: '0'
    nconnections: '2'
    type: float
    unit1: °
    unit2: °
  states: {}
- name: qtgui_number_sink_1_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: uncalibrated
    label2: calibrated
    max: '180'
    min: '0'
    name: '"Root MUSIC"'
    nconnections: '2'
    type: float
    unit1: °
    unit2: °
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    label1: With calibration
    label2: Without calibration
    nconnections: '2'
    showports: 'True'
    update_time: '0.05'
    vlen: input_variables.PSpectrumLength
    width1: '2'
    x_axis_label: '"angle (in degrees)"'
    x_start: '0'
    x_step: 180.0/input_variables.PSpectrumLength
    y_axis_label: '"Pseudo-Spectrum (dB)"'
    ymax: '0'
    ymin: '-30'
  states: {}
- name: variable_qtgui_msg_push_button_0_0
  id: variable_qtgui_msg_push_button
  parameters:
    label: Trigger_values
    msgName: pressed
    type: int
    value: '1'
  states: {}

connections:
- [blocks_complex_to_arg_0_0_0_0_1, '0', epy_block_4, '2']
- [blocks_complex_to_arg_0_0_0_0_1_0, '0', epy_block_5, '2']
- [blocks_complex_to_arg_0_0_0_1, '0', epy_block_4, '1']
- [blocks_complex_to_arg_0_0_0_1_0, '0', epy_block_5, '1']
- [blocks_complex_to_arg_0_0_1, '0', epy_block_4, '0']
- [blocks_complex_to_arg_0_0_1_0, '0', epy_block_5, '0']
- [blocks_divide_xx_0, '0', blocks_complex_to_arg_0_0_1, '0']
- [blocks_divide_xx_0_0, '0', blocks_complex_to_arg_0_0_0_1, '0']
- [blocks_divide_xx_0_0_0, '0', blocks_complex_to_arg_0_0_0_0_1, '0']
- [blocks_divide_xx_0_0_0_0, '0', blocks_complex_to_arg_0_0_0_0_1_0, '0']
- [blocks_divide_xx_0_0_1, '0', blocks_complex_to_arg_0_0_0_1_0, '0']
- [blocks_divide_xx_0_1, '0', blocks_complex_to_arg_0_0_1_0, '0']
- [doa_MUSIC_lin_array_0, '0', doa_find_local_max_0, '0']
- [doa_MUSIC_lin_array_0, '0', qtgui_vector_sink_f_0, '1']
- [doa_MUSIC_lin_array_0_0, '0', doa_find_local_max_0_0, '0']
- [doa_MUSIC_lin_array_0_0, '0', qtgui_vector_sink_f_0, '0']
- [doa_antenna_correction_0, '0', blocks_divide_xx_0_0_0_0, '0']
- [doa_antenna_correction_0, '0', blocks_divide_xx_0_0_1, '0']
- [doa_antenna_correction_0, '0', blocks_divide_xx_0_1, '0']
- [doa_antenna_correction_0, '0', doa_autocorrelate_0, '0']
- [doa_antenna_correction_0, '1', blocks_divide_xx_0_1, '1']
- [doa_antenna_correction_0, '1', doa_autocorrelate_0, '1']
- [doa_antenna_correction_0, '2', blocks_divide_xx_0_0_1, '1']
- [doa_antenna_correction_0, '2', doa_autocorrelate_0, '2']
- [doa_antenna_correction_0, '3', blocks_divide_xx_0_0_0_0, '1']
- [doa_antenna_correction_0, '3', doa_autocorrelate_0, '3']
- [doa_autocorrelate_0, '0', doa_MUSIC_lin_array_0, '0']
- [doa_autocorrelate_0, '0', doa_rootMUSIC_linear_array_0_0, '0']
- [doa_autocorrelate_0_0, '0', doa_MUSIC_lin_array_0_0, '0']
- [doa_autocorrelate_0_0, '0', doa_rootMUSIC_linear_array_0, '0']
- [doa_find_local_max_0, '0', blocks_null_sink_0_0, '1']
- [doa_find_local_max_0, '1', epy_block_3, '0']
- [doa_find_local_max_0, '1', qtgui_number_sink_1_0, '1']
- [doa_find_local_max_0_0, '0', blocks_null_sink_0_0, '0']
- [doa_find_local_max_0_0, '1', epy_block_2, '0']
- [doa_find_local_max_0_0, '1', qtgui_number_sink_1_0, '0']
- [doa_phase_correct_hier_0_0, '0', blocks_divide_xx_0, '0']
- [doa_phase_correct_hier_0_0, '0', blocks_divide_xx_0_0, '0']
- [doa_phase_correct_hier_0_0, '0', blocks_divide_xx_0_0_0, '0']
- [doa_phase_correct_hier_0_0, '0', doa_antenna_correction_0, '0']
- [doa_phase_correct_hier_0_0, '0', doa_autocorrelate_0_0, '0']
- [doa_phase_correct_hier_0_0, '1', blocks_divide_xx_0, '1']
- [doa_phase_correct_hier_0_0, '1', doa_antenna_correction_0, '1']
- [doa_phase_correct_hier_0_0, '1', doa_autocorrelate_0_0, '1']
- [doa_phase_correct_hier_0_0, '2', blocks_divide_xx_0_0, '1']
- [doa_phase_correct_hier_0_0, '2', doa_antenna_correction_0, '2']
- [doa_phase_correct_hier_0_0, '2', doa_autocorrelate_0_0, '2']
- [doa_phase_correct_hier_0_0, '3', blocks_divide_xx_0_0_0, '1']
- [doa_phase_correct_hier_0_0, '3', doa_antenna_correction_0, '3']
- [doa_phase_correct_hier_0_0, '3', doa_autocorrelate_0_0, '3']
- [doa_rootMUSIC_linear_array_0, '0', epy_block_1, '0']
- [doa_rootMUSIC_linear_array_0, '0', qtgui_number_sink_1_0_0, '0']
- [doa_rootMUSIC_linear_array_0_0, '0', epy_block_0, '0']
- [doa_rootMUSIC_linear_array_0_0, '0', qtgui_number_sink_1_0_0, '1']
- [doa_x440_usrp_source_0, '0', doa_phase_correct_hier_0_0, '0']
- [doa_x440_usrp_source_0, '1', doa_phase_correct_hier_0_0, '1']
- [doa_x440_usrp_source_0, '2', doa_phase_correct_hier_0_0, '2']
- [doa_x440_usrp_source_0, '3', doa_phase_correct_hier_0_0, '3']
- [variable_qtgui_msg_push_button_0_0, pressed, epy_block_0, in]
- [variable_qtgui_msg_push_button_0_0, pressed, epy_block_1, in]
- [variable_qtgui_msg_push_button_0_0, pressed, epy_block_2, in]
- [variable_qtgui_msg_push_button_0_0, pressed, epy_block_3, in]
- [variable_qtgui_msg_push_button_0_0, pressed, epy_block_4, in]
- [variable_qtgui_msg_push_button_0_0, pressed, epy_block_5, in]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-992-ga7b5ef78
