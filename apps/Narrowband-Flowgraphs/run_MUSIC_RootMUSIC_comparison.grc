options:
  parameters:
    author: jreitmei
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: run_MUSIC_RootMUSIC_comparison
    output_language: python
    title: MUSIC RootMUSIC comparison
  states: {}

blocks:
- name: ant_locs
  id: variable
  parameters:
    value: numpy.dot(input_variables.NormSpacing, numpy.arange(input_variables.NumArrayElements/2, -input_variables.NumArrayElements/2, -1) if (input_variables.NumArrayElements%2==1) else numpy.arange(input_variables.NumArrayElements/2-0.5, -input_variables.NumArrayElements/2-0.5, -1))
  states: {}
- name: input_variables
  id: variable_struct
  parameters:
    comment: |-
      input_variables: 
      Contains all the user-defined variables.
    field0: ''
    field1: SampleRate
    field10: PSpectrumLength
    field11: DirectoryConfigFiles
    field12: RelativePhaseOffsets
    field2: CenterFreq
    field3: RxAddr
    field5: NumArrayElements
    field6: NormSpacing
    field7: SnapshotSize
    field8: OverlapSize
    field9: NumTargets
    value1: 1e6
    value10: 2**10
    value11: '"/tmp"'
    value12: '"measure_relative_phase_offsets_2495MHz.cfg"'
    value2: 2.495e9
    value3: '"addr=10.94.17.33"'
    value5: '4'
    value6: '0.5'
    value7: 2**15
    value8: 2**14
    value9: '1'
  states: {}
- name: rel_phase_offsets_file_name
  id: variable
  parameters:
    value: os.path.join(input_variables.DirectoryConfigFiles, input_variables.RelativePhaseOffsets)
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: input_variables.NumTargets
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: input_variables.NumTargets
    type: float
  states: {}
- name: blocks_vector_to_streams_0_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: input_variables.NumTargets
    type: float
  states: {}
- name: doa_MUSIC_lin_array_0
  id: doa_MUSIC_lin_array
  parameters:
    inputs: input_variables.NumArrayElements
    norm_spacing: input_variables.NormSpacing
    num_targets: input_variables.NumTargets
    pspectrum_len: input_variables.PSpectrumLength
  states: {}
- name: doa_autocorrelate_0
  id: doa_autocorrelate
  parameters:
    avg_method: Forward-Backward
    inputs: input_variables.NumArrayElements
    overlap_size: input_variables.OverlapSize
    snapshot_size: input_variables.SnapshotSize
  states: {}
- name: doa_find_local_max_0
  id: doa_find_local_max
  parameters:
    num_max_vals: input_variables.NumTargets
    vector_len: input_variables.PSpectrumLength
    x_max: '180.0'
    x_min: '0.0'
  states: {}
- name: doa_phase_correct_hier_0
  id: doa_phase_correct_hier
  parameters:
    config_filename: rel_phase_offsets_file_name
    num_ports: input_variables.NumArrayElements
  states: {}
- name: doa_rootMUSIC_linear_array_0
  id: doa_rootMUSIC_linear_array
  parameters:
    norm_spacing: input_variables.NormSpacing
    num_ant_ele: input_variables.NumArrayElements
    num_targets: input_variables.NumTargets
  states: {}
- name: doa_serial_connection_0_0
  id: doa_serial_connection
  parameters:
    baudrate: '115200'
    debug: 'True'
    dimensions: '1'
    high_hysteresis: '20.0'
    low_hysteresis: '3'
    mirror: 'False'
    port: /dev/ttyACM0
  states: {}
- name: doa_x440_usrp_source_0
  id: doa_x440_usrp_source
  parameters:
    addresses: input_variables.RxAddr
    center_freq: input_variables.CenterFreq
    device_args: master_clock_rate=250e6
    samp_rate: input_variables.SampleRate
    sources: input_variables.NumArrayElements
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_compass_0
  id: qtgui_compass
  parameters:
    fullNeedle: '1'
    gui_hint: (0,7,1,3)
    min_size: '250'
    name: Direction
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: Estimated angle MUSIC
    label2: Estimated angle RootMUSIC
    max: '180'
    min: '0'
    name: '"Angle Estimation"'
    nconnections: '2'
    type: float
    unit1: °
    unit2: °
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: (0,0,1,7)
    label1: estimated angle
    showports: 'True'
    update_time: '0.05'
    vlen: input_variables.PSpectrumLength
    width1: '2'
    x_axis_label: '"angle (in degrees)"'
    x_start: '0'
    x_step: 180.0/input_variables.PSpectrumLength
    y_axis_label: '"Pseudo-Spectrum (dB)"'
    ymax: '0'
    ymin: '-15'
  states: {}

connections:
- [blocks_vector_to_streams_0, '0', doa_serial_connection_0_0, '0']
- [blocks_vector_to_streams_0, '0', qtgui_number_sink_1, '0']
- [blocks_vector_to_streams_0_0, '0', qtgui_compass_0, '0']
- [blocks_vector_to_streams_0_0, '0', qtgui_number_sink_1, '1']
- [doa_MUSIC_lin_array_0, '0', doa_find_local_max_0, '0']
- [doa_MUSIC_lin_array_0, '0', qtgui_vector_sink_f_0, '0']
- [doa_autocorrelate_0, '0', doa_MUSIC_lin_array_0, '0']
- [doa_autocorrelate_0, '0', doa_rootMUSIC_linear_array_0, '0']
- [doa_find_local_max_0, '0', blocks_null_sink_0, '0']
- [doa_find_local_max_0, '1', blocks_vector_to_streams_0, '0']
- [doa_phase_correct_hier_0, '0', doa_autocorrelate_0, '0']
- [doa_phase_correct_hier_0, '1', doa_autocorrelate_0, '1']
- [doa_phase_correct_hier_0, '2', doa_autocorrelate_0, '2']
- [doa_phase_correct_hier_0, '3', doa_autocorrelate_0, '3']
- [doa_rootMUSIC_linear_array_0, '0', blocks_vector_to_streams_0_0, '0']
- [doa_x440_usrp_source_0, '0', doa_phase_correct_hier_0, '0']
- [doa_x440_usrp_source_0, '1', doa_phase_correct_hier_0, '1']
- [doa_x440_usrp_source_0, '2', doa_phase_correct_hier_0, '2']
- [doa_x440_usrp_source_0, '3', doa_phase_correct_hier_0, '3']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-992-ga7b5ef78
