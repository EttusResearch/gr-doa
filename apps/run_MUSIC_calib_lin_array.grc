options:
  parameters:
    author: jreitmei
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: run_MUSIC_calib_lin_array
    output_language: python
    title: run_MUSIC_calib_lin_array
  states: {}

blocks:
- name: antenna_calibration_file_name
  id: variable
  parameters:
    value: os.path.join(input_variables.DirectoryConfigFiles, input_variables.AntennaCalibration)
  states: {}
- name: input_variables
  id: variable_struct
  parameters:
    comment: |-
      input_variables: 
      Contains all the user-defined variables.
    field0: ToneFreq
    field1: SampleRate
    field10: PSpectrumLength
    field11: DirectoryConfigFiles
    field12: RelativePhaseOffsets
    field13: AntennaCalibration
    field2: CenterFreq
    field3: RxAddr
    field4: Gain
    field5: NumArrayElements
    field6: NormSpacing
    field7: SnapshotSize
    field8: OverlapSize
    field9: NumTargets
    value0: 5e3
    value1: 2e5
    value10: 2**10
    value11: '"/tmp"'
    value12: '"measure_relative_phase_offsets_446.cfg"'
    value13: '"calibration_lin_array_446.cfg"'
    value2: '2495000000'
    value3: '"addr=10.94.17.19"'
    value4: '0'
    value5: '4'
    value6: '0.5'
    value7: 2**11
    value8: 2**10
    value9: '1'
  states: {}
- name: rel_phase_offsets_file_name
  id: variable
  parameters:
    value: os.path.join(input_variables.DirectoryConfigFiles, input_variables.RelativePhaseOffsets)
  states: {}
- name: blocks_add_xx_2
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_2_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_2_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_3
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_arg_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_arg_0_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_arg_0_0_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_arg_0_0_0_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_arg_0_0_0_0_1
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_arg_0_0_0_1
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_arg_0_0_1
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_divide_xx_0_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_divide_xx_0_0_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: input_variables.NumTargets
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_sub_xx_0_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: doa_MUSIC_lin_array_0
  id: doa_MUSIC_lin_array
  parameters:
    inputs: input_variables.NumArrayElements
    norm_spacing: input_variables.NormSpacing
    num_targets: input_variables.NumTargets
    pspectrum_len: input_variables.PSpectrumLength
  states: {}
- name: doa_antenna_correction_0
  id: doa_antenna_correction
  parameters:
    config_filename: antenna_calibration_file_name
    num_ant_ele: input_variables.NumArrayElements
  states: {}
- name: doa_autocorrelate_0
  id: doa_autocorrelate
  parameters:
    avg_method: Forward-Backward
    inputs: input_variables.NumArrayElements
    overlap_size: input_variables.OverlapSize
    snapshot_size: input_variables.SnapshotSize
  states: {}
- name: doa_find_local_max_0
  id: doa_find_local_max
  parameters:
    num_max_vals: input_variables.NumTargets
    vector_len: input_variables.PSpectrumLength
    x_max: '180.0'
    x_min: '0.0'
  states: {}
- name: doa_phase_correct_hier_0_0
  id: doa_phase_correct_hier
  parameters:
    config_filename: /tmp/measure_relative_phase_offsets_446.cfg
    num_ports: input_variables.NumArrayElements
  states: {}
- name: doa_x440_usrp_source_0
  id: doa_x440_usrp_source
  parameters:
    addresses: input_variables.RxAddr
    center_freq: input_variables.CenterFreq
    device_args: master_clock_rate=250e6
    gain: input_variables.Gain
    samp_rate: input_variables.SampleRate
    sources: input_variables.NumArrayElements
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: 0 - 1
    label2: 0 - 1
    label3: 0 - 2
    max: '10'
    min: '-10'
    name: '"Phase difference"'
    nconnections: '3'
    type: float
    unit1: °
    unit2: °
    unit3: °
    update_time: '0.01'
  states: {state: disabled}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '180'
    min: '0'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    nconnections: '4'
    size: '1024'
    srate: input_variables.SampleRate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    nconnections: '3'
    size: '1024'
    srate: input_variables.SampleRate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    nconnections: '3'
    size: '1024'
    srate: input_variables.SampleRate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {state: disabled}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    showports: 'True'
    update_time: '0.05'
    vlen: input_variables.PSpectrumLength
    width1: '2'
    x_axis_label: '"angle (in degrees)"'
    x_start: '0'
    x_step: 180.0/input_variables.PSpectrumLength
    y_axis_label: '"Pseudo-Spectrum (dB)"'
    ymax: '0'
    ymin: '-20'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: chn_0
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: chn_3
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: chn_1
  states: {}
- name: virtual_sink_0_0_1
  id: virtual_sink
  parameters:
    stream_id: chn_2
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: chn_0
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: chn_1
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: chn_2
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: chn_2
  states: {}
- name: virtual_source_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: chn_2
  states: {state: disabled}
- name: virtual_source_0_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: chn_2
  states: {state: disabled}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: chn_3
  states: {}
- name: virtual_source_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: chn_3
  states: {}
- name: virtual_source_0_0_1_1
  id: virtual_source
  parameters:
    stream_id: chn_3
  states: {state: disabled}
- name: virtual_source_0_0_1_1_0
  id: virtual_source
  parameters:
    stream_id: chn_3
  states: {state: disabled}
- name: virtual_source_0_0_2
  id: virtual_source
  parameters:
    stream_id: chn_1
  states: {}
- name: virtual_source_0_0_3
  id: virtual_source
  parameters:
    stream_id: chn_1
  states: {state: disabled}
- name: virtual_source_0_0_3_0
  id: virtual_source
  parameters:
    stream_id: chn_1
  states: {state: disabled}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: chn_0
  states: {}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: chn_0
  states: {state: disabled}
- name: virtual_source_0_2_0
  id: virtual_source
  parameters:
    stream_id: chn_0
  states: {state: disabled}

connections:
- [blocks_add_xx_2, '0', qtgui_time_sink_x_0, '1']
- [blocks_add_xx_2_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_add_xx_2_1, '0', qtgui_time_sink_x_0, '3']
- [blocks_add_xx_3, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_arg_0_0, '0', blocks_sub_xx_0, '0']
- [blocks_complex_to_arg_0_0, '0', blocks_sub_xx_0_0, '0']
- [blocks_complex_to_arg_0_0, '0', blocks_sub_xx_0_0_0, '0']
- [blocks_complex_to_arg_0_0_0, '0', blocks_sub_xx_0, '1']
- [blocks_complex_to_arg_0_0_0_0, '0', blocks_sub_xx_0_0, '1']
- [blocks_complex_to_arg_0_0_0_0_0, '0', blocks_sub_xx_0_0_0, '1']
- [blocks_complex_to_arg_0_0_0_0_1, '0', qtgui_time_sink_x_0_0_0, '2']
- [blocks_complex_to_arg_0_0_0_1, '0', qtgui_time_sink_x_0_0_0, '1']
- [blocks_complex_to_arg_0_0_1, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_complex_to_float_0, '0', blocks_add_xx_3, '0']
- [blocks_complex_to_float_0, '1', blocks_add_xx_3, '1']
- [blocks_complex_to_float_1, '0', blocks_add_xx_2, '0']
- [blocks_complex_to_float_1, '1', blocks_add_xx_2, '1']
- [blocks_complex_to_float_1_0, '0', blocks_add_xx_2_0, '0']
- [blocks_complex_to_float_1_0, '1', blocks_add_xx_2_0, '1']
- [blocks_complex_to_float_1_1, '0', blocks_add_xx_2_1, '0']
- [blocks_complex_to_float_1_1, '1', blocks_add_xx_2_1, '1']
- [blocks_divide_xx_0, '0', blocks_complex_to_arg_0_0_1, '0']
- [blocks_divide_xx_0_0, '0', blocks_complex_to_arg_0_0_0_1, '0']
- [blocks_divide_xx_0_0_0, '0', blocks_complex_to_arg_0_0_0_0_1, '0']
- [blocks_sub_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_sub_xx_0_0, '0', qtgui_number_sink_0, '1']
- [blocks_sub_xx_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_sub_xx_0_0_0, '0', qtgui_number_sink_0, '2']
- [blocks_sub_xx_0_0_0, '0', qtgui_time_sink_x_0_0, '2']
- [doa_MUSIC_lin_array_0, '0', doa_find_local_max_0, '0']
- [doa_MUSIC_lin_array_0, '0', qtgui_vector_sink_f_0, '0']
- [doa_antenna_correction_0, '0', doa_autocorrelate_0, '0']
- [doa_antenna_correction_0, '1', doa_autocorrelate_0, '1']
- [doa_antenna_correction_0, '2', doa_autocorrelate_0, '2']
- [doa_antenna_correction_0, '3', doa_autocorrelate_0, '3']
- [doa_autocorrelate_0, '0', doa_MUSIC_lin_array_0, '0']
- [doa_find_local_max_0, '0', blocks_null_sink_0, '0']
- [doa_find_local_max_0, '1', qtgui_number_sink_1, '0']
- [doa_phase_correct_hier_0_0, '0', doa_antenna_correction_0, '0']
- [doa_phase_correct_hier_0_0, '1', doa_antenna_correction_0, '1']
- [doa_phase_correct_hier_0_0, '2', doa_antenna_correction_0, '2']
- [doa_phase_correct_hier_0_0, '3', doa_antenna_correction_0, '3']
- [doa_x440_usrp_source_0, '0', virtual_sink_0, '0']
- [doa_x440_usrp_source_0, '1', virtual_sink_0_0_0, '0']
- [doa_x440_usrp_source_0, '2', virtual_sink_0_0_1, '0']
- [doa_x440_usrp_source_0, '3', virtual_sink_0_0, '0']
- [virtual_source_0, '0', doa_phase_correct_hier_0_0, '0']
- [virtual_source_0_0, '0', doa_phase_correct_hier_0_0, '1']
- [virtual_source_0_0_0, '0', doa_phase_correct_hier_0_0, '2']
- [virtual_source_0_0_0_0, '0', blocks_complex_to_float_1_0, '0']
- [virtual_source_0_0_0_1, '0', blocks_complex_to_arg_0_0_0_0, '0']
- [virtual_source_0_0_0_1_0, '0', blocks_divide_xx_0_0, '1']
- [virtual_source_0_0_1, '0', doa_phase_correct_hier_0_0, '3']
- [virtual_source_0_0_1_0, '0', blocks_complex_to_float_1_1, '0']
- [virtual_source_0_0_1_1, '0', blocks_complex_to_arg_0_0_0_0_0, '0']
- [virtual_source_0_0_1_1_0, '0', blocks_divide_xx_0_0_0, '1']
- [virtual_source_0_0_2, '0', blocks_complex_to_float_1, '0']
- [virtual_source_0_0_3, '0', blocks_complex_to_arg_0_0_0, '0']
- [virtual_source_0_0_3_0, '0', blocks_divide_xx_0, '1']
- [virtual_source_0_1, '0', blocks_complex_to_float_0, '0']
- [virtual_source_0_2, '0', blocks_complex_to_arg_0_0, '0']
- [virtual_source_0_2_0, '0', blocks_divide_xx_0, '0']
- [virtual_source_0_2_0, '0', blocks_divide_xx_0_0, '0']
- [virtual_source_0_2_0, '0', blocks_divide_xx_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-988-g6cadd695
