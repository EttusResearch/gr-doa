options:
  parameters:
    author: jreitmei
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: default
    output_language: python
    title: run Root calib lin array
  states: {}

blocks:
- name: antenna_calibration_file_name
  id: variable
  parameters:
    value: os.path.join(input_variables.DirectoryConfigFiles, input_variables.AntennaCalibration)
  states: {}
- name: input_variables
  id: variable_struct
  parameters:
    comment: |-
      input_variables: 
      Contains all the user-defined variables.
    field0: ToneFreq
    field1: SampleRate
    field10: PSpectrumLength
    field11: DirectoryConfigFiles
    field12: RelativePhaseOffsets
    field13: AntennaCalibration
    field2: CenterFreq
    field3: RxAddr
    field4: Gain
    field5: NumArrayElements
    field6: NormSpacing
    field7: SnapshotSize
    field8: OverlapSize
    field9: NumTargets
    value0: 5e3
    value1: 200e3
    value10: 2**10
    value11: '"/tmp"'
    value12: '"measure_relative_phase_offsets_446.cfg"'
    value13: '"calibration_lin_array_446.cfg"'
    value2: '446031250'
    value3: '"addr=10.94.17.29"'
    value4: '60'
    value5: '4'
    value6: '0.250'
    value7: 2**11
    value8: 2**9
    value9: '1'
  states: {}
- name: rel_phase_offsets_file_name
  id: variable
  parameters:
    value: os.path.join(input_variables.DirectoryConfigFiles, input_variables.RelativePhaseOffsets)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: doa_antenna_correction_0
  id: doa_antenna_correction
  parameters:
    config_filename: antenna_calibration_file_name
    num_ant_ele: input_variables.NumArrayElements
  states: {}
- name: doa_autocorrelate_0
  id: doa_autocorrelate
  parameters:
    avg_method: Forward
    inputs: input_variables.NumArrayElements
    overlap_size: input_variables.OverlapSize
    snapshot_size: input_variables.SnapshotSize
  states: {}
- name: doa_phase_correct_hier_0
  id: doa_phase_correct_hier
  parameters:
    config_filename: rel_phase_offsets_file_name
    num_ports: input_variables.NumArrayElements
  states: {}
- name: doa_rootMUSIC_linear_array_0
  id: doa_rootMUSIC_linear_array
  parameters:
    norm_spacing: input_variables.NormSpacing
    num_ant_ele: '4'
    num_targets: input_variables.NumTargets
  states: {}
- name: doa_x440_usrp_source_0
  id: doa_x440_usrp_source
  parameters:
    addresses: input_variables.RxAddr
    center_freq: input_variables.CenterFreq
    device_args: master_clock_rate=200e6
    gain: input_variables.Gain
    samp_rate: input_variables.SampleRate
    sources: input_variables.NumArrayElements
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '180'
    min: '0'
    type: float
  states: {}

connections:
- [doa_antenna_correction_0, '0', doa_autocorrelate_0, '0']
- [doa_antenna_correction_0, '1', doa_autocorrelate_0, '1']
- [doa_antenna_correction_0, '2', doa_autocorrelate_0, '2']
- [doa_antenna_correction_0, '3', doa_autocorrelate_0, '3']
- [doa_autocorrelate_0, '0', doa_rootMUSIC_linear_array_0, '0']
- [doa_phase_correct_hier_0, '0', doa_antenna_correction_0, '0']
- [doa_phase_correct_hier_0, '1', doa_antenna_correction_0, '1']
- [doa_phase_correct_hier_0, '2', doa_antenna_correction_0, '2']
- [doa_phase_correct_hier_0, '3', doa_antenna_correction_0, '3']
- [doa_rootMUSIC_linear_array_0, '0', qtgui_number_sink_1, '0']
- [doa_x440_usrp_source_0, '0', doa_phase_correct_hier_0, '0']
- [doa_x440_usrp_source_0, '1', doa_phase_correct_hier_0, '1']
- [doa_x440_usrp_source_0, '2', doa_phase_correct_hier_0, '2']
- [doa_x440_usrp_source_0, '3', doa_phase_correct_hier_0, '3']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-988-g6cadd695
