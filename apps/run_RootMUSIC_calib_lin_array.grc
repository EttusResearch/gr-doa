options:
  parameters:
    author: jreitmei
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: run_RootMUSIC_calib_lin_array
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: antenna_calibration_file_name
  id: variable
  parameters:
    value: os.path.join(input_variables.DirectoryConfigFiles, input_variables.AntennaCalibration)
  states: {}
- name: input_variables
  id: variable_struct
  parameters:
    comment: |-
      input_variables: 
      Contains all the user-defined variables.
    field0: ToneFreq
    field1: SampleRate
    field11: DirectoryConfigFiles
    field12: RelativePhaseOffsets
    field13: AntennaCalibration
    field2: CenterFreq
    field3: RxAddr
    field5: NumArrayElements
    field6: NormSpacing
    field7: SnapshotSize
    field8: OverlapSize
    field9: NumTargets
    value0: 5e3
    value1: 1e6
    value11: '"/tmp"'
    value12: '"measure_relative_phase_offsets_2495MHz.cfg"'
    value13: '"calibration_lin_array_2495MHz.cfg"'
    value2: 2.495e9
    value3: '"addr=10.94.17.48"'
    value5: '4'
    value6: '0.5'
    value7: 2**12
    value8: 2**11
    value9: '1'
  states: {}
- name: rel_phase_offsets_file_name
  id: variable
  parameters:
    value: os.path.join(input_variables.DirectoryConfigFiles, input_variables.RelativePhaseOffsets)
  states: {}
- name: doa_antenna_correction_0
  id: doa_antenna_correction
  parameters:
    config_filename: antenna_calibration_file_name
    num_ant_ele: input_variables.NumArrayElements
  states: {}
- name: doa_autocorrelate_0
  id: doa_autocorrelate
  parameters:
    avg_method: Forward-Backward
    inputs: input_variables.NumArrayElements
    overlap_size: input_variables.OverlapSize
    snapshot_size: input_variables.SnapshotSize
  states: {}
- name: doa_autocorrelate_0_0
  id: doa_autocorrelate
  parameters:
    avg_method: Forward-Backward
    inputs: input_variables.NumArrayElements
    overlap_size: input_variables.OverlapSize
    snapshot_size: input_variables.SnapshotSize
  states: {state: disabled}
- name: doa_phase_correct_hier_0_0
  id: doa_phase_correct_hier
  parameters:
    config_filename: rel_phase_offsets_file_name
    num_ports: input_variables.NumArrayElements
  states: {}
- name: doa_rootMUSIC_linear_array_0
  id: doa_rootMUSIC_linear_array
  parameters:
    norm_spacing: input_variables.NormSpacing
    num_ant_ele: '4'
    num_targets: input_variables.NumTargets
  states: {}
- name: doa_rootMUSIC_linear_array_0_0
  id: doa_rootMUSIC_linear_array
  parameters:
    norm_spacing: input_variables.NormSpacing
    num_ant_ele: '4'
    num_targets: input_variables.NumTargets
  states: {state: disabled}
- name: doa_x440_usrp_source_0
  id: doa_x440_usrp_source
  parameters:
    addresses: input_variables.RxAddr
    center_freq: input_variables.CenterFreq
    device_args: master_clock_rate=250e6
    samp_rate: input_variables.SampleRate
    sources: input_variables.NumArrayElements
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nfrom datetime import datetime\nimport os\n\nclass blk(gr.sync_block):\n    \"\"\"Triggered Float Recorder with Sample Skipping\"\"\"\n\n    def __init__(self, skip_interval=20):\n        gr.sync_block.__init__(\n            self,\n            name='Triggered Float Recorder with Skipping',\n            in_sig=[np.float32],\n            out_sig=[]\n        )\n\n        self.angle = 0\n        self.folder = \"testdata\"\n        os.makedirs(self.folder, exist_ok=True)\n\n        self.recording = False\n        self.skip_interval = skip_interval\n        self.samples_to_record = 10\n        self.skip_counter = 0\n        self.recorded_samples = []\n\n        # Message-Port für Trigger\n        self.message_port_register_in(gr.pmt.intern(\"in\"))\n        self.set_msg_handler(gr.pmt.intern(\"in\"), self.handle_trigger)\n\n    def handle_trigger(self, msg):\n        if not self.recording and self.angle <= 180:\n            print(f\"[Trigger] Aufnahme gestartet bei Winkel {self.angle}°\")\n            self.recording = True\n            self.recorded_samples = []\n            self.skip_counter = 0\n\n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n\n        for sample in in0:\n            if self.recording:\n                if self.skip_counter == 0:\n                    self.recorded_samples.append(sample)\n                    self.skip_counter = self.skip_interval\n                else:\n                    self.skip_counter -= 1\n\n                if len(self.recorded_samples) >= self.samples_to_record:\n                    # Speichern\n                    timestamp = datetime.now().strftime(\"%Y%m%d_%H%M%S\")\n                    filename = f\"aufnahme_{self.angle}deg_{timestamp}.dat\"\n                    filepath = os.path.join(self.folder, filename)\n\n                    with open(filepath, \"w\") as f:\n                        for s in self.recorded_samples:\n                            f.write(f\"{s}\\n\")\n\n                    print(f\"[Recorder] Datei gespeichert: {filepath}\")\n\n                    # Aufnahme zurücksetzen\n                    self.recording = False\n                    self.angle += 10\n\n                    if self.angle > 180:\n                        print(\"[Recorder] Maximale Winkelgrenze erreicht. Aufnahme beendet.\")\n                    break  # Aufnahme abgeschlossen\n\n        return len(in0)\n\n"
    skip_interval: '10'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_compass_0
  id: qtgui_compass
  parameters:
    fullNeedle: '1'
    min_size: '250'
  states: {}
- name: qtgui_number_sink_1_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '180'
    min: '0'
    type: float
  states: {}
- name: qtgui_number_sink_1_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '180'
    min: '0'
    type: float
  states: {state: disabled}
- name: variable_qtgui_msg_push_button_0
  id: variable_qtgui_msg_push_button
  parameters:
    label: Trigger_values
    msgName: pressed
    type: int
    value: '1'
  states: {}

connections:
- [doa_antenna_correction_0, '0', doa_autocorrelate_0, '0']
- [doa_antenna_correction_0, '1', doa_autocorrelate_0, '1']
- [doa_antenna_correction_0, '2', doa_autocorrelate_0, '2']
- [doa_antenna_correction_0, '3', doa_autocorrelate_0, '3']
- [doa_autocorrelate_0, '0', doa_rootMUSIC_linear_array_0, '0']
- [doa_autocorrelate_0_0, '0', doa_rootMUSIC_linear_array_0_0, '0']
- [doa_phase_correct_hier_0_0, '0', doa_antenna_correction_0, '0']
- [doa_phase_correct_hier_0_0, '0', doa_autocorrelate_0_0, '0']
- [doa_phase_correct_hier_0_0, '1', doa_antenna_correction_0, '1']
- [doa_phase_correct_hier_0_0, '1', doa_autocorrelate_0_0, '1']
- [doa_phase_correct_hier_0_0, '2', doa_antenna_correction_0, '2']
- [doa_phase_correct_hier_0_0, '2', doa_autocorrelate_0_0, '2']
- [doa_phase_correct_hier_0_0, '3', doa_antenna_correction_0, '3']
- [doa_phase_correct_hier_0_0, '3', doa_autocorrelate_0_0, '3']
- [doa_rootMUSIC_linear_array_0, '0', epy_block_0, '0']
- [doa_rootMUSIC_linear_array_0, '0', qtgui_compass_0, '0']
- [doa_rootMUSIC_linear_array_0, '0', qtgui_number_sink_1_0, '0']
- [doa_rootMUSIC_linear_array_0_0, '0', qtgui_number_sink_1_0_0, '0']
- [doa_x440_usrp_source_0, '0', doa_phase_correct_hier_0_0, '0']
- [doa_x440_usrp_source_0, '1', doa_phase_correct_hier_0_0, '1']
- [doa_x440_usrp_source_0, '2', doa_phase_correct_hier_0_0, '2']
- [doa_x440_usrp_source_0, '3', doa_phase_correct_hier_0_0, '3']
- [variable_qtgui_msg_push_button_0, pressed, epy_block_0, in]

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-988-gd3090973
