options:
  parameters:
    author: jreitmei
    generate_options: no_gui
    generator_class_name: PythonNoGuiGenerator
    generator_module: gnuradio.grc.workflows.python_nogui
    id: run_DoA_transmitter_WIFI
    output_language: python
    title: DoA Transmitter WiFi
  states: {}

blocks:
- name: input_variables
  id: variable_struct
  parameters:
    comment: |-
      input_variables: 
      Contains all the user-defined variables.
    field0: ''
    field1: SampleRate
    field2: CenterFreq
    field3: RxAddr
    field4: Gain
    value1: 2.5e6
    value2: 2.495e9
    value3: '"addr=192.168.10.2"'
    value4: '30'
  states: {}
- name: doa_signal_replay_cpp_0
  id: doa_signal_replay_cpp
  parameters:
    filename: /home/jreitmei/workarea/gr-doa/predefined_signal/20MHz_5_4_oversampling_05msframe_45mssilent.npy
    interpolation: '1'
    repeat: 'True'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: input_variables.CenterFreq
    dev_addr: input_variables.RxAddr
    gain0: input_variables.Gain
    samp_rate: input_variables.SampleRate
    sync: sync
    type: fc32
  states: {}

connections:
- [doa_signal_replay_cpp_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-992-ga7b5ef78
