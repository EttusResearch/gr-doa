options:
  parameters:
    author: jreitmei
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: run_MUSIC_lin_array_WiFi
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: input_variables
  id: variable_struct
  parameters:
    comment: |-
      input_variables: 
      Contains all the user-defined variables.
    field0: ''
    field1: SampleRate
    field10: PSpectrumLength
    field11: DirectoryConfigFiles
    field12: RelativePhaseOffsets
    field2: CenterFreq
    field3: RxAddr
    field5: NumArrayElements
    field6: NormSpacing
    field7: SnapshotSize
    field8: OverlapSize
    field9: NumTargets
    value1: 2.5e6
    value10: 2**10
    value11: '"/tmp"'
    value12: '"measure_relative_phase_offsets_2495MHz.cfg"'
    value2: 2.495e9
    value3: '"addr=10.94.17.59"'
    value5: '4'
    value6: '0.5'
    value7: 2**15
    value8: 2**14
    value9: '1'
  states: {}
- name: rel_phase_offsets_file_name
  id: variable
  parameters:
    value: os.path.join(input_variables.DirectoryConfigFiles, input_variables.RelativePhaseOffsets)
  states: {}
- name: doa_autocorrelate_0_0
  id: doa_autocorrelate
  parameters:
    avg_method: Forward
    inputs: input_variables.NumArrayElements
    overlap_size: input_variables.OverlapSize
    snapshot_size: input_variables.SnapshotSize
  states: {}
- name: doa_phase_correct_hier_0
  id: doa_phase_correct_hier
  parameters:
    config_filename: rel_phase_offsets_file_name
    num_ports: input_variables.NumArrayElements
  states: {}
- name: doa_power_detection_cpp_0
  id: doa_power_detection_cpp
  parameters:
    buffer_size: '5000'
    num_inputs: input_variables.NumArrayElements
    sample_rate: input_variables.SampleRate
    threshold: '1e-6'
  states: {}
- name: doa_rootMUSIC_linear_array_0_0
  id: doa_rootMUSIC_linear_array
  parameters:
    norm_spacing: input_variables.NormSpacing
    num_ant_ele: '4'
    num_targets: input_variables.NumTargets
  states: {}
- name: doa_x440_usrp_source_0
  id: doa_x440_usrp_source
  parameters:
    addresses: input_variables.RxAddr
    center_freq: input_variables.CenterFreq
    device_args: master_clock_rate=250e6
    samp_rate: input_variables.SampleRate
    sources: input_variables.NumArrayElements
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_compass_0
  id: qtgui_compass
  parameters:
    fullNeedle: '1'
    min_size: '250'
    name: Direction
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: Estimated angle
    max: '180'
    min: '0'
    type: float
    unit1: °
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Signal output"'
    nconnections: '4'
    size: '100000'
    srate: input_variables.SampleRate
    type: complex
  states: {}

connections:
- [doa_autocorrelate_0_0, '0', doa_rootMUSIC_linear_array_0_0, '0']
- [doa_phase_correct_hier_0, '0', doa_autocorrelate_0_0, '0']
- [doa_phase_correct_hier_0, '1', doa_autocorrelate_0_0, '1']
- [doa_phase_correct_hier_0, '2', doa_autocorrelate_0_0, '2']
- [doa_phase_correct_hier_0, '3', doa_autocorrelate_0_0, '3']
- [doa_power_detection_cpp_0, '0', doa_phase_correct_hier_0, '0']
- [doa_power_detection_cpp_0, '1', doa_phase_correct_hier_0, '1']
- [doa_power_detection_cpp_0, '2', doa_phase_correct_hier_0, '2']
- [doa_power_detection_cpp_0, '3', doa_phase_correct_hier_0, '3']
- [doa_rootMUSIC_linear_array_0_0, '0', qtgui_compass_0, '0']
- [doa_rootMUSIC_linear_array_0_0, '0', qtgui_number_sink_1, '0']
- [doa_x440_usrp_source_0, '0', doa_power_detection_cpp_0, '0']
- [doa_x440_usrp_source_0, '0', qtgui_time_sink_x_0, '0']
- [doa_x440_usrp_source_0, '1', doa_power_detection_cpp_0, '1']
- [doa_x440_usrp_source_0, '1', qtgui_time_sink_x_0, '1']
- [doa_x440_usrp_source_0, '2', doa_power_detection_cpp_0, '2']
- [doa_x440_usrp_source_0, '2', qtgui_time_sink_x_0, '2']
- [doa_x440_usrp_source_0, '3', doa_power_detection_cpp_0, '3']
- [doa_x440_usrp_source_0, '3', qtgui_time_sink_x_0, '3']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-992-ga7b5ef78
