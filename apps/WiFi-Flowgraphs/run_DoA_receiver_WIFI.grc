options:
  parameters:
    author: jreitmei
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: run_DoA_receiver_WIFI
    output_language: python
    title: DoA Receiver WiFi
  states: {}

blocks:
- name: input_variables
  id: variable_struct
  parameters:
    comment: |-
      input_variables: 
      Contains all the user-defined variables.
    field0: ''
    field1: SampleRate
    field2: CenterFreq
    field3: RxAddr
    field4: Gain
    value1: 2.5e6
    value2: 2.495e9
    value3: '"addr=10.94.17.16"'
    value4: '0'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: doa_power_detection_0
  id: doa_power_detection
  parameters:
    buffer_size: '12502'
    num_inputs: '1'
    sample_rate: input_variables.SampleRate
    threshold: '1e-6'
  states: {}
- name: doa_x440_usrp_source_0
  id: doa_x440_usrp_source
  parameters:
    addresses: input_variables.RxAddr
    center_freq: input_variables.CenterFreq
    device_args: master_clock_rate=250e6
    samp_rate: input_variables.SampleRate
    sources: '4'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: 1024 * 200
    srate: input_variables.SampleRate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: input_variables.SampleRate
    fc: '0'
    fftsize: '1024'
    type: complex
    update_time: '0.01'
  states: {}

connections:
- [doa_power_detection_0, '0', qtgui_time_sink_x_0, '0']
- [doa_power_detection_0, '0', qtgui_waterfall_sink_x_0, '0']
- [doa_x440_usrp_source_0, '0', doa_power_detection_0, '0']
- [doa_x440_usrp_source_0, '1', blocks_null_sink_0, '0']
- [doa_x440_usrp_source_0, '2', blocks_null_sink_1, '0']
- [doa_x440_usrp_source_0, '3', blocks_null_sink_2, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-992-ga7b5ef78
