options:
  parameters:
    author: jreitmei
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: test_detection
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '25000'
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: doa_power_detection_0
  id: doa_power_detection
  parameters:
    buffer_size: '12502'
    num_inputs: '4'
    sample_rate: samp_rate
    threshold: '1e-6'
  states: {state: disabled}
- name: doa_power_detection_cpp_0
  id: doa_power_detection_cpp
  parameters:
    buffer_size: '2000'
    num_inputs: '4'
    sample_rate: samp_rate
    threshold: '1e-5'
  states: {}
- name: doa_signal_replay_0
  id: doa_signal_replay
  parameters:
    filename: /home/jreitmei/workarea/gr-doa/predefined_signal/20MHz_5_4_oversampling_05msframe_45mssilent.npy
    interpolation: '1'
    repeat: 'True'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Signal output"'
    nconnections: '4'
    size: samp_rate
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: samp_rate
    srate: samp_rate
    type: complex
  states: {state: disabled}

connections:
- [blocks_throttle2_0_0, '0', doa_power_detection_0, '0']
- [blocks_throttle2_0_0, '0', doa_power_detection_0, '1']
- [blocks_throttle2_0_0, '0', doa_power_detection_0, '2']
- [blocks_throttle2_0_0, '0', doa_power_detection_0, '3']
- [blocks_throttle2_0_0, '0', doa_power_detection_cpp_0, '0']
- [blocks_throttle2_0_0, '0', doa_power_detection_cpp_0, '1']
- [blocks_throttle2_0_0, '0', doa_power_detection_cpp_0, '2']
- [blocks_throttle2_0_0, '0', doa_power_detection_cpp_0, '3']
- [blocks_throttle2_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [doa_power_detection_0, '0', qtgui_time_sink_x_0, '0']
- [doa_power_detection_0, '1', qtgui_time_sink_x_0, '1']
- [doa_power_detection_0, '2', qtgui_time_sink_x_0, '2']
- [doa_power_detection_0, '3', qtgui_time_sink_x_0, '3']
- [doa_power_detection_cpp_0, '0', qtgui_time_sink_x_0, '0']
- [doa_power_detection_cpp_0, '1', qtgui_time_sink_x_0, '1']
- [doa_power_detection_cpp_0, '2', qtgui_time_sink_x_0, '2']
- [doa_power_detection_cpp_0, '3', qtgui_time_sink_x_0, '3']
- [doa_signal_replay_0, '0', blocks_throttle2_0_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-992-ga7b5ef78
