<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>view_X310_TwinRX_op_with_corrected_phase_offsets</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_struct</key>
<param><key>id</key><value>input_variables</value></param>
<param><key>value2</key><value>2450000000</value></param>
<param><key>comment</key><value>input_variables: 
Contains all the user-defined variables.</value></param>
<param><key>value6</key><value>"/tmp"</value></param>
<param><key>field0</key><value>SampleRate</value></param>
<param><key>field1</key><value>ToneFreq</value></param>
<param><key>field2</key><value>CenterFreq</value></param>
<param><key>field3</key><value>Gain</value></param>
<param><key>field4</key><value>NumArrayElements</value></param>
<param><key>field5</key><value>RxAddr</value></param>
<param><key>field6</key><value>DirectoryConfigFiles</value></param>
<param><key>field7</key><value>RelativePhaseOffsets</value></param>
<param><key>value3</key><value>60</value></param>
<param><key>value4</key><value>4</value></param>
<param><key>value7</key><value>"measure_X310_TwinRX_relative_phase_offsets_245.cfg"</value></param>
<param><key>value5</key><value>"addr=192.168.10.2"</value></param>
<param><key>value0</key><value>1000000</value></param>
<param><key>value1</key><value>10000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rel_phase_offsets_file_name</value></param>
<param><key>value</key><value>os.path.join(input_variables.DirectoryConfigFiles, input_variables.RelativePhaseOffsets)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import</value></param>
<param><key>import</key><value>import os</value></param>
</block>
<block>
<key>phase_correct_hier</key>
<param><key>id</key><value>phase_correct_hier_1</value></param>
<param><key>config_filename</key><value>rel_phase_offsets_file_name</value></param>
<param><key>num_ports</key><value>input_variables.NumArrayElements</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>entags</key><value>False</value></param>
<param><key>color1</key><value>"green"</value></param>
<param><key>label1</key><value>Channel #0: Real</value></param>
<param><key>color10</key><value>"blue"</value></param>
<param><key>label10</key><value></value></param>
<param><key>color2</key><value>"dark green"</value></param>
<param><key>label2</key><value>Channel #0: Imag</value></param>
<param><key>color3</key><value>"blue"</value></param>
<param><key>label3</key><value>Channel #1: Real</value></param>
<param><key>color4</key><value>"Dark Blue"</value></param>
<param><key>label4</key><value>Channel #1: Imag</value></param>
<param><key>color5</key><value>"red"</value></param>
<param><key>label5</key><value>Channel #2: Real</value></param>
<param><key>color6</key><value>"dark red"</value></param>
<param><key>label6</key><value>Channel #2: Imag</value></param>
<param><key>color7</key><value>"black"</value></param>
<param><key>label7</key><value>Channel #3: Real</value></param>
<param><key>color8</key><value>"black"</value></param>
<param><key>label8</key><value>Channel #3: Imag</value></param>
<param><key>color9</key><value>"dark green"</value></param>
<param><key>label9</key><value></value></param>
<param><key>nconnections</key><value>input_variables.NumArrayElements</value></param>
<param><key>size</key><value>256</value></param>
<param><key>srate</key><value>input_variables.SampleRate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.5</value></param>
</block>
<block>
<key>twinrx_usrp_source</key>
<param><key>id</key><value>twinrx_usrp_source_0</value></param>
<param><key>center_freq</key><value>input_variables.CenterFreq</value></param>
<param><key>addresses</key><value>input_variables.RxAddr</value></param>
<param><key>gain</key><value>input_variables.Gain</value></param>
<param><key>sources</key><value>input_variables.NumArrayElements</value></param>
<param><key>samp_rate</key><value>input_variables.SampleRate</value></param>
</block>
<connection><source_block_id>phase_correct_hier_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>phase_correct_hier_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>phase_correct_hier_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>phase_correct_hier_1</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>twinrx_usrp_source_0</source_block_id><sink_block_id>phase_correct_hier_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>twinrx_usrp_source_0</source_block_id><sink_block_id>phase_correct_hier_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>twinrx_usrp_source_0</source_block_id><sink_block_id>phase_correct_hier_1</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>twinrx_usrp_source_0</source_block_id><sink_block_id>phase_correct_hier_1</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
</flow_graph>
