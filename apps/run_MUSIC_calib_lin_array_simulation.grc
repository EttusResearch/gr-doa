options:
  parameters:
    author: jreitmei
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: run_MUSIC_calib_lin_array_simulation
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: amv0
  id: variable
  parameters:
    value: numpy.multiply(ant_coeffs, amv0_true)
  states: {}
- name: amv0_true
  id: variable
  parameters:
    value: numpy.exp(-1j*ant_locs*2*numpy.pi*numpy.cos(theta0))
  states: {}
- name: amv1
  id: variable
  parameters:
    value: numpy.multiply(ant_coeffs, amv1_true)
  states: {}
- name: amv1_true
  id: variable
  parameters:
    value: numpy.exp(-1j*ant_locs*2*numpy.pi*numpy.cos(theta1))
  states: {}
- name: ant_coeffs
  id: variable
  parameters:
    comment: |-
      These simulated antenna coefficients need 
      to be the same as those used in 
      apps/run_calib_lin_array_simulation.grc
    value: input_variables.AntGains*numpy.exp(1j*input_variables.AntPhases)
  states: {}
- name: ant_locs
  id: variable
  parameters:
    value: numpy.dot(0.5, numpy.arange(input_variables.NumArrayElements/2, -input_variables.NumArrayElements/2, -1) if (input_variables.NumArrayElements%2==1) else numpy.arange(input_variables.NumArrayElements/2-0.5, -input_variables.NumArrayElements/2-0.5, -1))
  states: {}
- name: antenna_calibration_file_name
  id: variable
  parameters:
    value: os.path.join(input_variables.DirectoryConfigFiles, input_variables.AntennaCalibration)
  states: {}
- name: array_manifold_matrix
  id: variable
  parameters:
    value: numpy.array([amv0, amv1]).transpose()
  states: {}
- name: input_variables
  id: variable_struct
  parameters:
    comment: |-
      input_variables: 
      Contains all the user-defined variables.
    field0: SampleRate
    field1: ToneFreq1
    field10: AntPhases
    field11: DirectoryConfigFiles
    field12: AntennaCalibration
    field2: ToneFreq2
    field3: NormSpacing
    field4: NumTargets
    field5: NumArrayElements
    field6: PSpectrumLength
    field7: SnapshotSize
    field8: OverlapSize
    field9: AntGains
    value0: '320000'
    value1: '10000'
    value10: numpy.array([ 0.28647672,  5.27248071,  2.71271102,  1.36970886])
    value11: '"/tmp"'
    value12: '"calibration_lin_array_simulated.cfg"'
    value2: '20000'
    value3: '0.5'
    value4: '2'
    value5: '4'
    value6: 2**10
    value7: 2**11
    value8: 2**9
    value9: numpy.array([ 0.94984789,  0.4544107 ,  0.34649469,  0.25083929])
  states: {}
- name: theta0
  id: variable
  parameters:
    value: numpy.pi*theta0_deg/180
  states: {}
- name: theta0_deg
  id: variable_qtgui_range
  parameters:
    label: AoA
    start: '0'
    step: '1'
    stop: '180'
    value: '30'
  states: {}
- name: theta1
  id: variable
  parameters:
    value: numpy.pi*theta1_deg/180
  states: {}
- name: theta1_deg
  id: variable_qtgui_range
  parameters:
    label: AoA
    start: '0'
    step: '1'
    stop: '180'
    value: '123'
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: '0.0005'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_0_0_0
  id: analog_noise_source_x
  parameters:
    amp: '0.5'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: input_variables.ToneFreq1
    offset: '0'
    phase: '0'
    samp_rate: input_variables.SampleRate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: input_variables.ToneFreq2
    offset: '0'
    phase: '0'
    samp_rate: input_variables.SampleRate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_matrix_xx_0
  id: blocks_multiply_matrix_xx
  parameters:
    A: array_manifold_matrix
    tag_propagation_policy: gr.TPP_ALL_TO_ALL
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: input_variables.NumTargets
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: input_variables.SampleRate
    type: complex
  states: {}
- name: blocks_vector_to_streams_0_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: input_variables.NumTargets
    type: float
  states: {}
- name: doa_MUSIC_lin_array_0
  id: doa_MUSIC_lin_array
  parameters:
    inputs: input_variables.NumArrayElements
    norm_spacing: input_variables.NormSpacing
    num_targets: input_variables.NumTargets
    pspectrum_len: input_variables.PSpectrumLength
  states: {}
- name: doa_antenna_correction_0
  id: doa_antenna_correction
  parameters:
    config_filename: /tmp/antennencalibration.cfg
    num_ant_ele: input_variables.NumArrayElements
  states: {}
- name: doa_autocorrelate_0
  id: doa_autocorrelate
  parameters:
    avg_method: Forward
    inputs: input_variables.NumArrayElements
    overlap_size: input_variables.OverlapSize
    snapshot_size: input_variables.SnapshotSize
  states: {}
- name: doa_find_local_max_0
  id: doa_find_local_max
  parameters:
    num_max_vals: input_variables.NumTargets
    vector_len: input_variables.PSpectrumLength
    x_max: '180.0'
    x_min: '0.0'
  states: {}
- name: doa_serial_connection_0
  id: doa_serial_connection
  parameters:
    baudrate: '115200'
    debug: 'False'
    dimensions: '1'
    enable_video: 'True'
    port: /dev/ttyACM0
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    max: '180'
    min: '0'
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    showports: 'True'
    update_time: '0.05'
    vlen: input_variables.PSpectrumLength
    width1: '2'
    x_axis_label: '"angle (in degrees)"'
    x_start: '0'
    x_step: 180.0/input_variables.PSpectrumLength
    y_axis_label: '"Pseudo-Spectrum (dB)"'
    ymax: '0'
    ymin: '-50'
  states: {}

connections:
- [analog_noise_source_x_0_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0_0_0, '0', blocks_add_xx_0_0, '1']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_matrix_xx_0, '0']
- [blocks_add_xx_0_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_matrix_xx_0, '0', doa_antenna_correction_0, '0']
- [blocks_multiply_matrix_xx_0, '1', doa_antenna_correction_0, '1']
- [blocks_multiply_matrix_xx_0, '2', doa_antenna_correction_0, '2']
- [blocks_multiply_matrix_xx_0, '3', doa_antenna_correction_0, '3']
- [blocks_throttle2_0, '0', blocks_multiply_matrix_xx_0, '1']
- [blocks_vector_to_streams_0_0, '0', qtgui_number_sink_1, '0']
- [blocks_vector_to_streams_0_0, '1', doa_serial_connection_0, '0']
- [blocks_vector_to_streams_0_0, '1', qtgui_number_sink_1, '1']
- [doa_MUSIC_lin_array_0, '0', doa_find_local_max_0, '0']
- [doa_MUSIC_lin_array_0, '0', qtgui_vector_sink_f_0, '0']
- [doa_antenna_correction_0, '0', doa_autocorrelate_0, '0']
- [doa_antenna_correction_0, '1', doa_autocorrelate_0, '1']
- [doa_antenna_correction_0, '2', doa_autocorrelate_0, '2']
- [doa_antenna_correction_0, '3', doa_autocorrelate_0, '3']
- [doa_autocorrelate_0, '0', doa_MUSIC_lin_array_0, '0']
- [doa_find_local_max_0, '0', blocks_null_sink_0, '0']
- [doa_find_local_max_0, '1', blocks_vector_to_streams_0_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-988-gd3090973
