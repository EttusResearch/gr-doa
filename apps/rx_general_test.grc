options:
  parameters:
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: rx_general_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: input_variables
  id: variable_struct
  parameters:
    comment: |-
      input_variables: 
      Contains all the user-defined variables.
    field0: ToneFreq
    field1: SampleRate
    field2: CenterFreq
    field3: RxAddr
    field4: Gain
    field5: NumArrayElements
    value0: 5e3
    value1: 0.1e6
    value2: 446.1e6
    value3: '"addr=192.168.40.2"'
    value4: '30'
    value5: '4'
  states: {}
- name: doa_x440_usrp_source_0
  id: doa_x440_usrp_source
  parameters:
    addresses: input_variables.RxAddr
    center_freq: input_variables.CenterFreq
    device_args: master_clock_rate=200e6
    gain: input_variables.Gain
    samp_rate: input_variables.SampleRate
    sources: '1'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: input_variables.SampleRate
    fc: input_variables.CenterFreq
    fftsize: '4096'
    name: '"RF Spectrum"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '10000'
    srate: input_variables.SampleRate
    type: complex
    ymax: '.3'
    ymin: '-.3'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: input_variables.SampleRate
    fc: input_variables.CenterFreq
    fftsize: '4096'
    name: '"Spectrum waterfall"'
    type: complex
    update_time: '0.1'
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: input_variables.CenterFreq
    dev_addr: input_variables.RxAddr
    gain0: input_variables.Gain
    samp_rate: input_variables.SampleRate
    sync: sync
    type: fc32
  states: {}

connections:
- [doa_x440_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-988-g6cadd695
