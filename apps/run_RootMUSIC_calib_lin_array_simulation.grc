options:
  parameters:
    author: jreitmei
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: run_RootMUSIC_calib_lin_array_simulation
    output_language: python
    title: RootMUSIC calibrated linear array simulation
  states: {}

blocks:
- name: amv0
  id: variable
  parameters:
    value: numpy.multiply(ant_coeffs, amv0_true)
  states: {}
- name: amv0_true
  id: variable
  parameters:
    value: numpy.exp(-1j*ant_locs*2*numpy.pi*numpy.cos(theta0))
  states: {}
- name: amv1
  id: variable
  parameters:
    value: numpy.multiply(ant_coeffs, amv1_true)
  states: {}
- name: amv1_true
  id: variable
  parameters:
    value: numpy.exp(-1j*ant_locs*2*numpy.pi*numpy.cos(theta1))
  states: {}
- name: ant_coeffs
  id: variable
  parameters:
    comment: |-
      These simulated antenna coefficients need 
      to be the same as those used in 
      apps/run_calib_lin_array_simulation.grc
    value: input_variables.AntGains*numpy.exp(1j*input_variables.AntPhases)
  states: {}
- name: ant_locs
  id: variable
  parameters:
    value: numpy.dot(input_variables.NormSpacing, numpy.arange(input_variables.NumArrayElements/2, -input_variables.NumArrayElements/2, -1) if (input_variables.NumArrayElements%2==1) else numpy.arange(input_variables.NumArrayElements/2-0.5, -input_variables.NumArrayElements/2-0.5, -1))
  states: {}
- name: antenna_calibration_file_name
  id: variable
  parameters:
    value: os.path.join(input_variables.DirectoryConfigFiles, input_variables.AntennaCalibration)
  states: {}
- name: array_manifold_matrix
  id: variable
  parameters:
    value: numpy.array([amv0, amv1]).transpose()
  states: {}
- name: input_variables
  id: variable_struct
  parameters:
    comment: |-
      input_variables: 
      Contains all the user-defined variables.
    field0: SampleRate
    field1: ToneFreq1
    field10: AntPhases
    field11: DirectoryConfigFiles
    field12: AntennaCalibration
    field2: ToneFreq2
    field3: NormSpacing
    field4: NumTargets
    field5: NumArrayElements
    field7: SnapshotSize
    field8: OverlapSize
    field9: AntGains
    value0: '320000'
    value1: '10000'
    value10: numpy.array([ 0.28647672,  5.27248071,  2.71271102,  1.36970886])
    value11: '"/tmp"'
    value12: '"calibration_lin_array_simulated.cfg"'
    value2: '5000'
    value3: '0.44'
    value4: '2'
    value5: '4'
    value7: 2**12
    value8: 2**11
    value9: numpy.array([ 0.94984789,  0.4544107 ,  0.34649469,  0.25083929])
  states: {}
- name: theta0
  id: variable
  parameters:
    value: numpy.pi*theta0_deg/180
  states: {}
- name: theta0_deg
  id: variable_qtgui_range
  parameters:
    label: AoA
    start: '0'
    step: '1'
    stop: '180'
    value: '30'
  states: {}
- name: theta1
  id: variable
  parameters:
    value: numpy.pi*theta1_deg/180
  states: {}
- name: theta1_deg
  id: variable_qtgui_range
  parameters:
    label: AoA
    start: '0'
    step: '1'
    stop: '180'
    value: '123'
  states: {}
- name: analog_noise_source_x_0_0
  id: analog_noise_source_x
  parameters:
    amp: '0.0005'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_noise_source_x_0_0_0
  id: analog_noise_source_x
  parameters:
    amp: '0.5'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: input_variables.ToneFreq1
    offset: '0'
    phase: '0'
    samp_rate: input_variables.SampleRate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: input_variables.ToneFreq2
    offset: '0'
    phase: '0'
    samp_rate: input_variables.SampleRate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_0_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_matrix_xx_0
  id: blocks_multiply_matrix_xx
  parameters:
    A: array_manifold_matrix
    tag_propagation_policy: gr.TPP_ALL_TO_ALL
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: input_variables.SampleRate
    type: complex
  states: {}
- name: blocks_vector_to_streams_0
  id: blocks_vector_to_streams
  parameters:
    num_streams: input_variables.NumTargets
    type: float
  states: {}
- name: doa_antenna_correction_0
  id: doa_antenna_correction
  parameters:
    config_filename: /tmp/antennencalibration.cfg
    num_ant_ele: input_variables.NumArrayElements
  states: {}
- name: doa_autocorrelate_0
  id: doa_autocorrelate
  parameters:
    avg_method: Forward
    inputs: input_variables.NumArrayElements
    overlap_size: input_variables.OverlapSize
    snapshot_size: input_variables.SnapshotSize
  states: {}
- name: doa_rootMUSIC_linear_array_0
  id: doa_rootMUSIC_linear_array
  parameters:
    norm_spacing: input_variables.NormSpacing
    num_ant_ele: input_variables.NumArrayElements
    num_targets: input_variables.NumTargets
  states: {}
- name: doa_serial_connection_0
  id: doa_serial_connection
  parameters:
    baudrate: '115200'
    debug: 'False'
    dimensions: '1'
    high_hysteresis: '15.0'
    low_hysteresis: '3.0'
    mirror: 'False'
    port: /dev/ttyACM0
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import os
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    label1: Estimated angle
    label2: Estimated angle
    max: '180'
    min: '0'
    nconnections: '2'
    type: float
    unit1: °
    unit2: °
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Direction of Arrival
    label1: Direction of Arrival
    num_tabs: '2'
  states: {}

connections:
- [analog_noise_source_x_0_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0_0_0, '0', blocks_add_xx_0_0, '1']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_add_xx_0_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_matrix_xx_0, '0']
- [blocks_add_xx_0_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_matrix_xx_0, '0', doa_antenna_correction_0, '0']
- [blocks_multiply_matrix_xx_0, '1', doa_antenna_correction_0, '1']
- [blocks_multiply_matrix_xx_0, '2', doa_antenna_correction_0, '2']
- [blocks_multiply_matrix_xx_0, '3', doa_antenna_correction_0, '3']
- [blocks_throttle2_0, '0', blocks_multiply_matrix_xx_0, '1']
- [blocks_vector_to_streams_0, '0', doa_serial_connection_0, '0']
- [blocks_vector_to_streams_0, '0', qtgui_number_sink_1, '0']
- [blocks_vector_to_streams_0, '1', qtgui_number_sink_1, '1']
- [doa_antenna_correction_0, '0', doa_autocorrelate_0, '0']
- [doa_antenna_correction_0, '1', doa_autocorrelate_0, '1']
- [doa_antenna_correction_0, '2', doa_autocorrelate_0, '2']
- [doa_antenna_correction_0, '3', doa_autocorrelate_0, '3']
- [doa_autocorrelate_0, '0', doa_rootMUSIC_linear_array_0, '0']
- [doa_rootMUSIC_linear_array_0, '0', blocks_vector_to_streams_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-992-ga7b5ef78
