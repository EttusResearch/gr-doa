options:
  parameters:
    author: jreitmei
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: X440_channel_test
    output_language: python
    title: Antenna Waterfall test
  states: {}

blocks:
- name: input_variables
  id: variable_struct
  parameters:
    comment: |-
      input_variables: 
      Contains all the user-defined variables.
    field0: ToneFreq
    field1: SampleRate
    field2: CenterFreq
    field3: RxAddr
    field4: Gain
    field5: NumArrayElements
    value0: 5e3
    value1: 200e3
    value2: '446031250 '
    value3: '"addr=10.94.17.47"'
    value4: '0'
    value5: '4'
  states: {}
- name: blocks_complex_to_arg_0_0_0_0_1
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_arg_0_0_0_1
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_arg_0_0_1
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_divide_xx_0_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_divide_xx_0_0_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: doa_x440_usrp_source_0_0
  id: doa_x440_usrp_source
  parameters:
    addresses: input_variables.RxAddr
    center_freq: input_variables.CenterFreq
    device_args: master_clock_rate=250e6
    maxoutbuf: '65536'
    minoutbuf: '16384'
    samp_rate: input_variables.SampleRate
    sources: input_variables.NumArrayElements
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: input_variables.SampleRate
    color2: '"green"'
    fc: input_variables.CenterFreq
    fftsize: '4096'
    grid: 'True'
    label1: 'Antenna 0 '
    label2: 'Antenna 1 '
    label3: 'Antenna 2 '
    label4: Antenna 3
    name: '"RF Spectrum Antenna 1"'
    nconnections: '4'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    nconnections: '3'
    size: '1024'
    srate: input_variables.SampleRate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: input_variables.SampleRate
    color3: '1'
    fc: input_variables.CenterFreq
    fftsize: '4096'
    label1: 'Antenna 0 '
    label2: Antenna 1
    label3: Antenna 2
    label4: Antenna 3
    name: '"Spectrum waterfall Antenna"'
    nconnections: '4'
    type: complex
    update_time: '0.1'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: chn_0
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: chn_3
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: chn_1
  states: {}
- name: virtual_sink_0_0_1
  id: virtual_sink
  parameters:
    stream_id: chn_2
  states: {}
- name: virtual_source_0_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: chn_2
  states: {state: disabled}
- name: virtual_source_0_0_1_1_0
  id: virtual_source
  parameters:
    stream_id: chn_3
  states: {state: disabled}
- name: virtual_source_0_0_3_0
  id: virtual_source
  parameters:
    stream_id: chn_1
  states: {state: disabled}
- name: virtual_source_0_2_0
  id: virtual_source
  parameters:
    stream_id: chn_0
  states: {state: disabled}

connections:
- [blocks_complex_to_arg_0_0_0_0_1, '0', qtgui_time_sink_x_0_0_0, '2']
- [blocks_complex_to_arg_0_0_0_1, '0', qtgui_time_sink_x_0_0_0, '1']
- [blocks_complex_to_arg_0_0_1, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_divide_xx_0, '0', blocks_complex_to_arg_0_0_1, '0']
- [blocks_divide_xx_0_0, '0', blocks_complex_to_arg_0_0_0_1, '0']
- [blocks_divide_xx_0_0_0, '0', blocks_complex_to_arg_0_0_0_0_1, '0']
- [doa_x440_usrp_source_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [doa_x440_usrp_source_0_0, '0', qtgui_waterfall_sink_x_0_0_1, '0']
- [doa_x440_usrp_source_0_0, '0', virtual_sink_0, '0']
- [doa_x440_usrp_source_0_0, '1', qtgui_freq_sink_x_0_0, '1']
- [doa_x440_usrp_source_0_0, '1', qtgui_waterfall_sink_x_0_0_1, '1']
- [doa_x440_usrp_source_0_0, '1', virtual_sink_0_0_0, '0']
- [doa_x440_usrp_source_0_0, '2', qtgui_freq_sink_x_0_0, '2']
- [doa_x440_usrp_source_0_0, '2', qtgui_waterfall_sink_x_0_0_1, '2']
- [doa_x440_usrp_source_0_0, '2', virtual_sink_0_0_1, '0']
- [doa_x440_usrp_source_0_0, '3', qtgui_freq_sink_x_0_0, '3']
- [doa_x440_usrp_source_0_0, '3', qtgui_waterfall_sink_x_0_0_1, '3']
- [doa_x440_usrp_source_0_0, '3', virtual_sink_0_0, '0']
- [virtual_source_0_0_0_1_0, '0', blocks_divide_xx_0_0, '1']
- [virtual_source_0_0_1_1_0, '0', blocks_divide_xx_0_0_0, '1']
- [virtual_source_0_0_3_0, '0', blocks_divide_xx_0, '1']
- [virtual_source_0_2_0, '0', blocks_divide_xx_0, '0']
- [virtual_source_0_2_0, '0', blocks_divide_xx_0_0, '0']
- [virtual_source_0_2_0, '0', blocks_divide_xx_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-992-ga7b5ef78
