options:
  parameters:
    author: jreitmei
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: X440_channel_test
    output_language: python
    title: Antenna Waterfall test
  states: {}

blocks:
- name: input_variables
  id: variable_struct
  parameters:
    comment: |-
      input_variables: 
      Contains all the user-defined variables.
    field0: ToneFreq
    field1: SampleRate
    field2: CenterFreq
    field3: RxAddr
    field4: Gain
    field5: NumArrayElements
    value0: 5e3
    value1: 200e3
    value2: '2495000000'
    value3: '"addr=10.94.17.19"'
    value4: '0'
    value5: '4'
  states: {}
- name: blocks_add_xx_2
  id: blocks_add_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_add_xx_2_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_add_xx_2_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_add_xx_3
  id: blocks_add_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_complex_to_arg_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_arg_0_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_arg_0_0_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_arg_0_0_0_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_arg_0_0_0_0_1
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_arg_0_0_0_1
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_arg_0_0_1
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_float_1_0
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_float_1_1
  id: blocks_complex_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0_0_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_divide_xx_0_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_divide_xx_0_0_0
  id: blocks_divide_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {state: disabled}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {state: disabled}
- name: blocks_moving_average_xx_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {state: disabled}
- name: blocks_moving_average_xx_0_0_1
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {state: disabled}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {state: disabled}
- name: blocks_nlog10_ff_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {state: disabled}
- name: blocks_nlog10_ff_0_0_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {state: disabled}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_sub_xx_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_sub_xx_0_0_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {state: disabled}
- name: doa_x440_usrp_source_0_0
  id: doa_x440_usrp_source
  parameters:
    addresses: input_variables.RxAddr
    center_freq: input_variables.CenterFreq
    device_args: master_clock_rate=250e6
    gain: input_variables.Gain
    maxoutbuf: '65536'
    minoutbuf: '16384'
    samp_rate: input_variables.SampleRate
    sources: input_variables.NumArrayElements
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: input_variables.SampleRate
    fc: input_variables.CenterFreq
    fftsize: '4096'
    grid: 'True'
    name: '"RF Spectrum Antenna 0"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: input_variables.SampleRate
    fc: input_variables.CenterFreq
    fftsize: '4096'
    grid: 'True'
    name: '"RF Spectrum Antenna 1"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: input_variables.SampleRate
    fc: input_variables.CenterFreq
    fftsize: '4096'
    grid: 'True'
    name: '"RF Spectrum Antenna 3"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: input_variables.SampleRate
    fc: input_variables.CenterFreq
    fftsize: '4096'
    grid: 'True'
    name: '"RF Spectrum Antenna 2"'
    type: complex
  states: {}
- name: qtgui_number_sink
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: Antenna 0
    label2: Antenna 1
    label3: Antenna 2
    label4: Antenna 3
    name: '"Antenna outputs"'
    nconnections: input_variables.NumArrayElements
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"Time Signals of sinuses"'
    nconnections: '4'
    size: '1024'
    srate: input_variables.SampleRate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    nconnections: '3'
    size: '1024'
    srate: input_variables.SampleRate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    nconnections: '3'
    size: '1024'
    srate: input_variables.SampleRate
    tr_mode: qtgui.TRIG_MODE_NORM
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: input_variables.SampleRate
    fc: input_variables.CenterFreq
    fftsize: '4096'
    name: '"Spectrum waterfall Antenna 0"'
    type: complex
    update_time: '0.1'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: input_variables.SampleRate
    fc: input_variables.CenterFreq
    fftsize: '4096'
    name: '"Spectrum waterfall Antenna 1"'
    type: complex
    update_time: '0.1'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: input_variables.SampleRate
    fc: input_variables.CenterFreq
    fftsize: '4096'
    name: '"Spectrum waterfall Antenna 2"'
    type: complex
    update_time: '0.1'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: input_variables.SampleRate
    fc: input_variables.CenterFreq
    fftsize: '4096'
    name: '"Spectrum waterfall Antenna 3"'
    type: complex
    update_time: '0.1'
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: chn_0
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: chn_3
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: chn_1
  states: {}
- name: virtual_sink_0_0_1
  id: virtual_sink
  parameters:
    stream_id: chn_2
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: chn_2
  states: {state: disabled}
- name: virtual_source_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: chn_2
  states: {state: disabled}
- name: virtual_source_0_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: chn_2
  states: {state: disabled}
- name: virtual_source_0_0_1_0
  id: virtual_source
  parameters:
    stream_id: chn_3
  states: {state: disabled}
- name: virtual_source_0_0_1_1
  id: virtual_source
  parameters:
    stream_id: chn_3
  states: {state: disabled}
- name: virtual_source_0_0_1_1_0
  id: virtual_source
  parameters:
    stream_id: chn_3
  states: {state: disabled}
- name: virtual_source_0_0_2
  id: virtual_source
  parameters:
    stream_id: chn_1
  states: {state: disabled}
- name: virtual_source_0_0_3
  id: virtual_source
  parameters:
    stream_id: chn_1
  states: {state: disabled}
- name: virtual_source_0_0_3_0
  id: virtual_source
  parameters:
    stream_id: chn_1
  states: {state: disabled}
- name: virtual_source_0_1
  id: virtual_source
  parameters:
    stream_id: chn_0
  states: {state: disabled}
- name: virtual_source_0_2
  id: virtual_source
  parameters:
    stream_id: chn_0
  states: {state: disabled}
- name: virtual_source_0_2_0
  id: virtual_source
  parameters:
    stream_id: chn_0
  states: {state: disabled}

connections:
- [blocks_add_xx_2, '0', qtgui_time_sink_x_0, '1']
- [blocks_add_xx_2_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_add_xx_2_1, '0', qtgui_time_sink_x_0, '3']
- [blocks_add_xx_3, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_arg_0_0, '0', blocks_sub_xx_0, '0']
- [blocks_complex_to_arg_0_0, '0', blocks_sub_xx_0_0, '0']
- [blocks_complex_to_arg_0_0, '0', blocks_sub_xx_0_0_0, '0']
- [blocks_complex_to_arg_0_0_0, '0', blocks_sub_xx_0, '1']
- [blocks_complex_to_arg_0_0_0_0, '0', blocks_sub_xx_0_0, '1']
- [blocks_complex_to_arg_0_0_0_0_0, '0', blocks_sub_xx_0_0_0, '1']
- [blocks_complex_to_arg_0_0_0_0_1, '0', qtgui_time_sink_x_0_0_0, '2']
- [blocks_complex_to_arg_0_0_0_1, '0', qtgui_time_sink_x_0_0_0, '1']
- [blocks_complex_to_arg_0_0_1, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_complex_to_float_0, '0', blocks_add_xx_3, '0']
- [blocks_complex_to_float_0, '1', blocks_add_xx_3, '1']
- [blocks_complex_to_float_1, '0', blocks_add_xx_2, '0']
- [blocks_complex_to_float_1, '1', blocks_add_xx_2, '1']
- [blocks_complex_to_float_1_0, '0', blocks_add_xx_2_0, '0']
- [blocks_complex_to_float_1_0, '1', blocks_add_xx_2_0, '1']
- [blocks_complex_to_float_1_1, '0', blocks_add_xx_2_1, '0']
- [blocks_complex_to_float_1_1, '1', blocks_add_xx_2_1, '1']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_0, '0', blocks_moving_average_xx_0_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_0_0, '0', blocks_moving_average_xx_0_0_1, '0']
- [blocks_divide_xx_0, '0', blocks_complex_to_arg_0_0_1, '0']
- [blocks_divide_xx_0_0, '0', blocks_complex_to_arg_0_0_0_1, '0']
- [blocks_divide_xx_0_0_0, '0', blocks_complex_to_arg_0_0_0_0_1, '0']
- [blocks_moving_average_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_moving_average_xx_0_0_0, '0', blocks_nlog10_ff_0_0_0, '0']
- [blocks_moving_average_xx_0_0_1, '0', blocks_nlog10_ff_0_0_1, '0']
- [blocks_nlog10_ff_0, '0', qtgui_number_sink, '0']
- [blocks_nlog10_ff_0_0, '0', qtgui_number_sink, '1']
- [blocks_nlog10_ff_0_0_0, '0', qtgui_number_sink, '2']
- [blocks_nlog10_ff_0_0_1, '0', qtgui_number_sink, '3']
- [blocks_sub_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_sub_xx_0_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_sub_xx_0_0_0, '0', qtgui_time_sink_x_0_0, '2']
- [doa_x440_usrp_source_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [doa_x440_usrp_source_0_0, '0', qtgui_freq_sink_x_0, '0']
- [doa_x440_usrp_source_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [doa_x440_usrp_source_0_0, '0', virtual_sink_0, '0']
- [doa_x440_usrp_source_0_0, '1', blocks_complex_to_mag_squared_0_0, '0']
- [doa_x440_usrp_source_0_0, '1', qtgui_freq_sink_x_0_0, '0']
- [doa_x440_usrp_source_0_0, '1', qtgui_waterfall_sink_x_0_0, '0']
- [doa_x440_usrp_source_0_0, '1', virtual_sink_0_0_0, '0']
- [doa_x440_usrp_source_0_0, '2', blocks_complex_to_mag_squared_0_0_0, '0']
- [doa_x440_usrp_source_0_0, '2', qtgui_freq_sink_x_0_1, '0']
- [doa_x440_usrp_source_0_0, '2', qtgui_waterfall_sink_x_0_0_0, '0']
- [doa_x440_usrp_source_0_0, '2', virtual_sink_0_0_1, '0']
- [doa_x440_usrp_source_0_0, '3', blocks_complex_to_mag_squared_0_0_0_0, '0']
- [doa_x440_usrp_source_0_0, '3', qtgui_freq_sink_x_0_0_0, '0']
- [doa_x440_usrp_source_0_0, '3', qtgui_waterfall_sink_x_0_0_1, '0']
- [doa_x440_usrp_source_0_0, '3', virtual_sink_0_0, '0']
- [virtual_source_0_0_0_0, '0', blocks_complex_to_float_1_0, '0']
- [virtual_source_0_0_0_1, '0', blocks_complex_to_arg_0_0_0_0, '0']
- [virtual_source_0_0_0_1_0, '0', blocks_divide_xx_0_0, '1']
- [virtual_source_0_0_1_0, '0', blocks_complex_to_float_1_1, '0']
- [virtual_source_0_0_1_1, '0', blocks_complex_to_arg_0_0_0_0_0, '0']
- [virtual_source_0_0_1_1_0, '0', blocks_divide_xx_0_0_0, '1']
- [virtual_source_0_0_2, '0', blocks_complex_to_float_1, '0']
- [virtual_source_0_0_3, '0', blocks_complex_to_arg_0_0_0, '0']
- [virtual_source_0_0_3_0, '0', blocks_divide_xx_0, '1']
- [virtual_source_0_1, '0', blocks_complex_to_float_0, '0']
- [virtual_source_0_2, '0', blocks_complex_to_arg_0_0, '0']
- [virtual_source_0_2_0, '0', blocks_divide_xx_0, '0']
- [virtual_source_0_2_0, '0', blocks_divide_xx_0_0, '0']
- [virtual_source_0_2_0, '0', blocks_divide_xx_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-988-g6cadd695
