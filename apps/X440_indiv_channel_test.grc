options:
  parameters:
    author: jreitmei
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: X440_channel_test
    output_language: python
    title: Antenna Waterfall test
  states: {}

blocks:
- name: input_variables
  id: variable_struct
  parameters:
    comment: |-
      input_variables: 
      Contains all the user-defined variables.
    field0: ToneFreq
    field1: SampleRate
    field2: CenterFreq
    field3: RxAddr
    field4: Gain
    field5: NumArrayElements
    value0: 5e3
    value1: 200e3
    value2: '446031250'
    value3: '"addr=10.94.17.29"'
    value4: '30'
    value5: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_moving_average_xx_0_0_1
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: blocks_nlog10_ff_0_0_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {}
- name: doa_x440_usrp_source_0_0
  id: doa_x440_usrp_source
  parameters:
    addresses: input_variables.RxAddr
    center_freq: input_variables.CenterFreq
    device_args: master_clock_rate=200e6
    gain: input_variables.Gain
    samp_rate: input_variables.SampleRate
    sources: input_variables.NumArrayElements
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: input_variables.SampleRate
    fc: input_variables.CenterFreq
    fftsize: '4096'
    grid: 'True'
    name: '"RF Spectrum Antenna 0"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: input_variables.SampleRate
    fc: input_variables.CenterFreq
    fftsize: '4096'
    grid: 'True'
    name: '"RF Spectrum Antenna 1"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: input_variables.SampleRate
    fc: input_variables.CenterFreq
    fftsize: '4096'
    grid: 'True'
    name: '"RF Spectrum Antenna 3"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: input_variables.SampleRate
    fc: input_variables.CenterFreq
    fftsize: '4096'
    grid: 'True'
    name: '"RF Spectrum Antenna 2"'
    type: complex
  states: {}
- name: qtgui_number_sink
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: Antenna 0
    label2: Antenna 1
    label3: Antenna 2
    label4: Antenna 3
    name: '"Antenna outputs"'
    nconnections: input_variables.NumArrayElements
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: input_variables.SampleRate
    fc: input_variables.CenterFreq
    fftsize: '4096'
    name: '"Spectrum waterfall Antenna 0"'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: input_variables.SampleRate
    fc: input_variables.CenterFreq
    fftsize: '4096'
    name: '"Spectrum waterfall Antenna 1"'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_waterfall_sink_x_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: input_variables.SampleRate
    fc: input_variables.CenterFreq
    fftsize: '4096'
    name: '"Spectrum waterfall Antenna 2"'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_waterfall_sink_x_0_0_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: input_variables.SampleRate
    fc: input_variables.CenterFreq
    fftsize: '4096'
    name: '"Spectrum waterfall Antenna 3"'
    type: complex
    update_time: '0.1'
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_0, '0', blocks_moving_average_xx_0_0_0, '0']
- [blocks_complex_to_mag_squared_0_0_0_0, '0', blocks_moving_average_xx_0_0_1, '0']
- [blocks_moving_average_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_moving_average_xx_0_0_0, '0', blocks_nlog10_ff_0_0_0, '0']
- [blocks_moving_average_xx_0_0_1, '0', blocks_nlog10_ff_0_0_1, '0']
- [blocks_nlog10_ff_0, '0', qtgui_number_sink, '0']
- [blocks_nlog10_ff_0_0, '0', qtgui_number_sink, '1']
- [blocks_nlog10_ff_0_0_0, '0', qtgui_number_sink, '2']
- [blocks_nlog10_ff_0_0_1, '0', qtgui_number_sink, '3']
- [doa_x440_usrp_source_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [doa_x440_usrp_source_0_0, '0', qtgui_freq_sink_x_0, '0']
- [doa_x440_usrp_source_0_0, '0', qtgui_waterfall_sink_x_0, '0']
- [doa_x440_usrp_source_0_0, '1', blocks_complex_to_mag_squared_0_0, '0']
- [doa_x440_usrp_source_0_0, '1', qtgui_freq_sink_x_0_0, '0']
- [doa_x440_usrp_source_0_0, '1', qtgui_waterfall_sink_x_0_0, '0']
- [doa_x440_usrp_source_0_0, '2', blocks_complex_to_mag_squared_0_0_0, '0']
- [doa_x440_usrp_source_0_0, '2', qtgui_freq_sink_x_0_1, '0']
- [doa_x440_usrp_source_0_0, '2', qtgui_waterfall_sink_x_0_0_0, '0']
- [doa_x440_usrp_source_0_0, '3', blocks_complex_to_mag_squared_0_0_0_0, '0']
- [doa_x440_usrp_source_0_0, '3', qtgui_freq_sink_x_0_0_0, '0']
- [doa_x440_usrp_source_0_0, '3', qtgui_waterfall_sink_x_0_0_1, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-988-g6cadd695
